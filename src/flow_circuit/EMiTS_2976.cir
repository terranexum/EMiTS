.title EMiTS_2976
R1 1 263 -0.025330295964295847
R2 2 263 -0.025330295945853586
R3 3 263 -0.02533029593071086
R4 4 263 -0.025330296239378526
R5 5 263 -0.02533029602262574
R6 6 263 -0.02533029591093115
R7 7 263 -0.025330295911716542
R8 8 263 -0.02533029591091774
R9 9 263 -0.025330295918208453
R10 10 263 -0.025330295921397714
R11 11 263 -0.025330295921397714
R12 12 263 -0.02533029591882162
R13 13 263 -0.025330295910732038
R14 14 263 -0.025330295910720706
R15 15 263 -0.025330295910607852
R16 16 263 -0.02533029592396124
R17 17 263 -0.025330295965002025
R18 18 263 -0.025330295929549926
R19 19 263 -0.025330295911050196
R20 20 263 -0.025330295958678726
R21 21 263 -0.025330366265862082
R22 22 263 -0.025330295925497955
R23 23 263 -0.025330295910607214
R24 24 263 -0.025330295911142667
R25 25 263 -0.025330295910584444
R26 26 263 -0.02533029591801757
R27 27 263 -0.02533029591659469
R28 28 263 -0.025330295921795715
R29 29 263 -0.02533029591516381
R30 30 263 -0.02533029592165809
R31 31 263 -0.025330295910673293
R32 32 263 -0.025330295946520063
R33 33 263 -0.025330295944202188
R34 34 263 -0.02533029593039913
R35 35 263 -0.02533029591250538
R36 36 263 -0.025330295910704206
R37 37 263 -0.025330295930932025
R38 38 263 -0.025330295930483183
R39 39 263 -0.025330296353112326
R40 40 263 -0.025330295930304718
R41 41 263 -0.02533029592941794
R42 42 263 -0.02533029593005371
R43 43 263 -0.025330295930596373
R44 44 263 -0.025330295930642007
R45 45 263 -0.025330366265862082
R46 46 263 -0.02533029591106317
R47 47 263 -0.02533029591845227
R48 48 263 -0.025330295916066056
R49 49 263 -0.025330295934574195
R50 50 263 -0.025330295910622188
R51 51 263 -0.02533029591254204
R52 52 263 -0.025330295910619877
R53 53 263 -0.02533029592894612
R54 54 263 -0.025330295933937225
R55 55 263 -0.02533029591088012
R56 56 263 -0.025330295912756914
R57 57 263 -0.025330295912501667
R58 58 263 -0.025330295919815872
R59 59 263 -0.02533029602805011
R60 60 263 -0.025330295938242438
R61 61 263 -0.025330295922740963
R62 62 263 -0.02533029591552178
R63 63 263 -0.025330296074981485
R64 64 263 -0.025330295942994362
R65 65 263 -0.025330296009407383
R66 66 263 -0.02533029606387842
R67 67 263 -0.025330296013302597
R68 68 263 -0.02533029591300846
R69 69 263 -0.025330295931364696
R70 70 263 -0.02533029593008609
R71 71 263 -0.025330295929657888
R72 72 263 -0.02533029585722997
R73 73 263 -0.025330295874242858
R74 74 263 -0.025330295884838254
R75 75 263 -0.025330295835577155
R76 76 263 -0.025330295835262355
R77 77 263 -0.025330295910565723
R78 78 263 -0.025330295877181212
R79 79 263 -0.025330295850013645
R80 80 263 -0.025330295848660558
R81 81 263 -0.025330295880443852
R82 82 263 -0.02533029585860374
R83 83 263 -0.025330295872443294
R84 84 263 -0.025330295752254723
R85 85 263 -0.025330295847543087
R86 86 263 -0.02533029587659878
R87 87 263 -0.025330295875246305
R88 88 263 -0.025330295854792986
R89 89 263 -0.025330295857033638
R90 90 263 -0.025330295836521254
R91 91 263 -0.025330295910565723
R92 92 263 -0.025330295826849876
R93 93 263 -0.025330295802152295
R94 94 263 -0.025330295887436457
R95 95 263 -0.025330295864994884
R96 96 263 -0.025330295902963894
R97 97 263 -0.02533029568768573
R98 98 263 -0.02533029571204099
R99 99 263 -0.0253302956929543
R100 100 263 -0.02533029567400502
R101 101 263 -0.02533029571796149
R102 102 263 -0.02533029571533529
R103 103 263 -0.025330295697703367
R104 104 263 -0.0253302957234183
R105 105 263 -0.02533029571437282
R106 106 263 -0.02533029588481173
R107 107 263 -0.025330295832890957
R108 108 263 -0.0253302958607179
R109 109 263 -0.025330295910565723
R110 110 263 -0.02533029586879307
R111 111 263 -0.025330295807256823
R112 112 263 -0.02533029585497261
R113 113 263 -0.02533029584580256
R114 114 263 -0.02533029589827748
R115 115 263 -0.025330295871525885
R116 116 263 -0.025330295869914636
R117 117 263 -0.025330295901969148
R118 118 263 -0.025330295910565723
R119 119 263 -0.025330295795180115
R120 120 263 -0.025330295867983108
R121 121 263 -0.025330295886801416
R122 122 263 -0.02533029582426076
R123 123 263 -0.025330295867987726
R124 124 263 -0.025330295846897822
R125 125 263 -0.025330295863236475
R126 126 263 -0.025330295849726375
R127 127 263 -0.025330295833483684
R128 128 263 -0.025330295903122715
R129 129 263 -0.025330295871755237
R130 130 263 -0.025330295910565723
R131 131 263 -0.02533029577554448
R132 132 263 -0.025330295849067982
R133 133 263 -0.02533029583059985
R134 134 263 -0.025330295890969034
R135 135 263 -0.025330295849992638
R136 136 263 -0.02533029579692913
R137 137 263 -0.025330295910565723
R138 138 263 -0.025330295831811546
R139 139 263 -0.025330295850740543
R140 140 263 -0.025330295805608333
R141 141 263 -0.025330295890534937
R142 142 263 -0.025330295842908464
R143 143 263 -0.025330295832690832
R144 144 263 -0.02533029576105069
R145 145 263 -0.02533029585867335
R146 146 263 -0.025330295910565723
R147 147 263 -0.025330295881942973
R148 148 263 -0.025330295407868672
R149 149 263 -0.025330295763344116
R150 150 263 -0.02533029586912734
R151 151 263 -0.02533029580988667
R152 152 263 -0.02533029550613414
R153 153 263 -0.02533029588762452
R154 154 263 -0.02533029587122678
R155 155 263 -0.025330295870726893
R156 156 263 -0.025330295792475414
R157 157 263 -0.025330295860287077
R158 158 263 -0.025330295792807857
R159 159 263 -0.025330295834451805
R160 160 263 -0.025330295910565723
R161 161 263 -0.025330295815357336
R162 162 263 -0.02533029585713546
R163 163 263 -0.025330295910565723
R164 164 263 -0.025330295910565723
R165 165 263 -0.025330295843341472
R166 166 263 -0.025330295851329364
R167 167 263 -0.02533029584966199
R168 168 263 -0.02533029575115404
R169 169 263 -0.025330295838685613
R170 170 263 -0.025330295446665825
R171 171 263 -0.025330295893370748
R172 172 263 -0.025330295910565723
R173 173 263 -0.025330295910565723
R174 174 263 -0.02533029583023429
R175 175 263 -0.025330295817231327
R176 176 263 -0.025330295766417817
R177 177 263 -0.025330295910565723
R178 178 263 -0.025330295910565723
R179 179 263 -0.025330295836006406
R180 180 263 -0.0253302958124244
R181 181 263 -0.025330295910565723
R182 182 263 -0.025330295910565723
R183 183 263 -0.02533029582585099
R184 184 263 -0.025330295708534005
R185 185 263 -0.025330295826753498
R186 186 263 -0.025330295743377737
R187 187 263 -0.025330295910565723
R188 188 263 -0.025330295781740925
R189 189 263 -0.025330295816230898
R190 190 263 -0.025330295735628998
R191 191 263 -0.025330295816429697
R192 192 263 -0.025330295810602328
R193 193 263 -0.02533029580672435
R194 194 263 -0.02533029587772818
R195 195 263 -0.025330295910565723
R196 196 263 -0.0253302957931374
R197 197 263 -0.025330295910565723
R198 198 263 -0.025330295777513452
R199 199 263 -0.025330295910565723
R200 200 263 -0.025330295732903896
R201 201 263 -0.025330295669940273
R202 202 263 -0.025330295755646805
R203 203 263 -0.02533029564519036
R204 204 263 -0.025330295910565723
R205 205 263 -0.025330295867380063
R206 206 263 -0.025330295851250108
R207 207 263 -0.025330295811535578
R208 208 263 -0.025330295910565723
R209 209 263 -0.025330295873620838
R210 210 263 -0.02533029582984488
R211 211 263 -0.025330295844314944
R212 212 263 -0.025330295850347562
R213 213 263 -0.02533029587565132
R214 214 263 -0.025330295413428024
R215 215 263 -0.02533029578350636
R216 216 263 -0.0253302958346734
R217 217 263 -0.025330295632274496
R218 218 263 -0.025330295904724725
R219 219 263 -0.025330295908792468
R220 220 263 -0.025330295879680657
R221 221 263 -0.02533029590269517
R222 222 263 -0.025330295808408607
R223 223 263 -0.025330295872791682
R224 224 263 -0.025330295910565723
R225 225 263 -0.025330295870806985
R226 226 263 -0.025330295910565723
R227 227 263 -0.025330295910565723
R228 228 263 -0.025330295784243357
R229 229 263 -0.025330295910565723
R230 230 263 -0.025330295855832068
R231 231 263 -0.025330295845010474
R232 232 263 -0.0253302958674422
R233 233 263 -0.02533029586784818
R234 234 263 -0.025330295883461435
R235 235 263 -0.02533029581226969
R236 236 263 -0.025330295878841853
R237 237 263 -0.025330295864513814
R238 238 263 -0.025330295883656793
R239 239 263 -0.02533029584329451
R240 240 263 -0.025330295831968844
R241 241 263 -0.025330295886456952
R242 242 263 -0.025330295899206014
R243 243 263 -0.025330295851333996
R244 244 263 -0.025330295781432314
R245 245 263 -0.025330295748154225
R246 246 263 -0.025330295842165854
R247 247 263 -0.025330295910565723
R248 248 263 -0.025330295910565723
R249 249 263 -0.025330295910565723
R250 250 263 -0.025330295910565723
R251 251 263 -0.025330295910565723
R252 252 263 -0.02533029589131471
R253 253 263 -0.025330295910565723
R254 254 263 -0.025330295910565723
R255 255 263 -0.025330295714009004
R256 256 263 -0.025330295903480342
R257 257 263 -0.025330295910565723
R258 258 263 -0.025330295910565723
R259 259 263 -0.025330295720381094
R260 260 263 -0.025330295853238642
R261 261 263 -0.02533029590393465
R262 262 263 -0.02533029582668079
R263 263 400 -0.05066059182116889
R264 263 264 -0.02533029586675634
R265 263 265 -0.025330295850753578
R266 263 266 -0.025330295910565723
R267 263 267 -0.02533029539423433
R268 263 268 -0.025330295853229004
R269 263 269 -0.02533029579165668
R270 263 270 -0.025330295840252724
R271 263 271 -0.0253302957328381
R272 263 272 -0.02533029563254794
R273 263 273 -0.025330295877719067
R274 263 274 -0.025330295885807225
R275 263 275 -0.025330295632979345
R276 263 276 -0.025330295910565723
R277 263 277 -0.025330295532041473
R278 263 278 -0.025330295749990513
R279 263 279 -0.0253302958023031
R280 263 280 -0.02533029585582523
R281 263 281 -0.025330295868882968
R282 263 282 -0.025330295910565723
R283 263 283 -0.025330295910565723
R284 263 284 -0.02533029578509759
R285 263 285 -0.02533029577793044
R286 263 286 -0.02533029572233843
R287 263 287 -0.025330295910565723
R288 263 288 -0.02533029589078892
R289 263 289 -0.025330295866217704
R290 263 290 -0.02533029586449845
R291 263 291 -0.02533029590803323
R292 263 292 -0.025330295910565723
R293 263 293 -0.025330295910565723
R294 263 294 -0.025330295860252112
R295 263 295 -0.025330295783780685
R296 263 296 -0.025330295828176235
R297 263 297 -0.0253302957065848
R298 263 298 -0.025330295893514328
R299 263 299 -0.025330295910565723
R300 263 300 -0.025330295856316933
R301 263 301 -0.025330295910565723
R302 263 302 -0.025330295910565723
R303 263 303 -0.025330295756893762
R304 263 304 -0.02533029572251559
R305 263 305 -0.025330295756859217
R306 263 306 -0.025330295910565723
R307 263 307 -0.025330295910565723
R308 263 308 -0.02533029551780385
R309 263 309 -0.025330295780014733
R310 263 310 -0.02533029575861643
R311 263 311 -0.025330295910565723
R312 263 312 -0.02533029585951021
R313 263 313 -0.025330295910565723
R314 263 314 -0.025330295910565723
R315 263 315 -0.025330295081152594
R316 263 316 -0.025330295684798484
R317 263 317 -0.025330295809356345
R318 263 318 -0.025330295910565723
R319 263 319 -0.02533029589851884
R320 263 320 -0.02533029581149004
R321 263 321 -0.025330295910565723
R322 263 322 -0.025330295442544386
R323 263 323 -0.025330295910565723
R324 263 324 -0.02533029558643922
R325 263 325 -0.025330295751996145
R326 263 326 -0.025330295910565723
R327 263 327 -0.025330295910565723
R328 263 328 -0.02533029579204719
R329 263 329 -0.02533029585666595
R330 263 330 -0.025330295629922134
R331 263 331 -0.025330295788157996
R332 263 332 -0.025330295910565723
R333 263 333 -0.025330295856799082
R334 263 334 -0.025330295803613175
R335 263 335 -0.025330295910565723
R336 263 336 -0.02533029585265456
R337 263 337 -0.025330295840897275
R338 263 338 -0.025330295725010384
R339 263 339 -0.025330295788634907
R340 263 340 -0.025330295836523936
R341 263 341 -0.025330295804498405
R342 263 342 -0.025330295735517292
R343 263 343 -0.025330295910565723
R344 263 344 -0.02533029578681833
R345 263 345 -0.025330295910565723
R346 263 346 -0.025330295910565723
R347 263 347 -0.025330295781433216
R348 263 348 -0.025330295726759246
R349 263 349 -0.025330295910565723
R350 263 350 -0.025330295833179018
R351 263 351 -0.025330295821549255
R352 263 352 -0.025330295910565723
R353 263 353 -0.02533029585140535
R354 263 354 -0.025330295910565723
R355 263 355 -0.025330295808906153
R356 263 356 -0.025330295811551096
R357 263 357 -0.025330295805208774
R358 263 358 -0.02533029582026215
R359 263 359 -0.02533029586538291
R360 263 360 -0.025330295782814916
R361 263 361 -0.025330295910565723
R362 263 362 -0.025330295885130034
R363 263 363 -0.0253302958422471
R364 263 364 -0.025330295505772222
R365 263 365 -0.025330295800537563
R366 263 366 -0.025330295812123056
R367 263 367 -0.02533029589026005
R368 263 368 -0.025330295910565723
R369 263 369 -0.025330295780892444
R370 263 370 -0.025330295910565723
R371 263 371 -0.025330294825708782
R372 263 372 -0.02533029563440479
R373 263 373 -0.025330295894929505
R374 263 374 -0.025330295873773726
R375 263 375 -0.02533029569698533
R376 263 376 -0.025330295807719044
R377 263 377 -0.025330295910565723
R378 263 378 -0.025330295910565723
R379 263 379 -0.025330295756145146
R380 263 380 -0.025330295910565723
R381 263 381 -0.025330295841813188
R382 263 382 -0.025330295910565723
R383 263 383 -0.025330295910565723
R384 263 384 -0.02533029580030833
R385 263 385 -0.025330295910565723
R386 263 386 -0.025330295910565723
R387 263 387 -0.025330295665474584
R388 263 388 -0.025330295881046832
R389 263 389 -0.02533029586440764
R390 263 390 -0.02533029577147051
R391 263 391 -0.025330295873826493
R392 263 392 -0.02533029586179069
R393 263 393 -0.025330295883278453
R394 263 394 -0.025330295831944735
R395 263 395 -0.025330295780055984
R396 263 396 -0.02533029580526255
R397 263 397 -0.025330295747446694
R398 263 398 -0.025330295910565723
R399 263 399 -0.025330295716807835
R400 263 401 -0.05066059182116889
R401 263 402 -0.025330295778565864
R402 263 403 -0.025330295868107734
R403 263 404 -0.025330295781797588
R404 263 405 -0.02533029584912192
R405 263 406 -0.025330295880988223
R406 263 407 -0.025330295789813977
R407 263 408 -0.025330295878525134
R408 263 409 -0.02533029588680533
R409 263 410 -0.025330295847754637
R410 263 411 -0.025330295910565723
R411 263 412 -0.0253302958545956
R412 263 413 -0.02533029590091437
R413 263 414 -0.025330295910565723
R414 263 415 -0.025330295910565723
R415 263 416 -0.025330295910565723
R416 263 417 -0.02533029586875664
R417 263 418 -0.025330295734480035
R418 263 419 -0.025330295910565723
R419 263 420 -0.02533029589379377
R420 263 421 -0.02533029586706737
R421 263 422 -0.02533029587845262
R422 263 423 -0.02533029589872991
R423 263 424 -0.025330295721928704
R424 263 425 -0.025330295893794184
R425 263 426 -0.025330295807816375
R426 263 427 -0.025330295886953822
R427 263 428 -0.025330295867782585
R428 263 429 -0.02533029583587656
R429 263 430 -0.025330294732696865
R430 263 431 -0.025330295789238857
R431 263 432 -0.025330295730551105
R432 263 433 -0.02533029577313851
R433 263 434 -0.02533029579540695
R434 263 435 -0.025330295894174584
R435 263 436 -0.025330295892038005
R436 263 437 -0.025330295873493124
R437 263 438 -0.025330295847889744
R438 263 439 -0.025330295885776323
R439 263 440 -0.025330295865953326
R440 263 441 -0.025330295886071868
R441 263 442 -0.025330295882047108
R442 263 443 -0.025330295899757573
R443 263 444 -0.025330295885412246
R444 263 445 -0.02533029586453489
R445 263 446 -0.02533029585283982
R446 263 447 -0.025330295910565723
R447 263 448 -0.025330295841279046
R448 263 449 -0.025330295890579856
R449 263 450 -0.025330295757480827
R450 263 451 -0.025330295874155966
R451 263 452 -0.025330295910565723
R452 263 453 -0.02533029588526561
R453 263 454 -0.02533029570944678
R454 263 455 -0.025330295860315027
R455 263 456 -0.025330295806795945
R456 263 457 -0.02533029581698153
R457 263 458 -0.025330295910565723
R458 263 459 -0.02533029583715148
R459 263 460 -0.02533029588315626
R460 263 461 -0.025330295889601593
R461 263 462 -0.025330295910565723
R462 263 463 -0.025330295883577252
R463 263 464 -0.02533029521899079
R464 263 465 -0.025330295760365704
R465 263 466 -0.02533029578658968
R466 263 467 -0.02533029582957439
R467 263 468 -0.025330295910565723
R468 263 469 -0.025330295845629798
R469 263 470 -0.02533029588841263
R470 263 471 -0.02533029579749238
R471 263 472 -0.025330295793092084
R472 263 473 -0.025330295910565723
R473 263 474 -0.025330295823260626
R474 263 475 -0.02533029582159378
R475 263 476 -0.025330295863516795
R476 263 477 -0.02533029586993186
R477 263 478 -0.025330295910565723
R478 263 479 -0.025330295854195686
R479 263 480 -0.025330295794601967
R480 263 481 -0.025330295897941585
R481 263 482 -0.025330295880847002
R482 263 483 -0.025330295891143266
R483 263 484 -0.025330295895398088
R484 263 485 -0.025330295712096832
R485 263 486 -0.025330295820791476
R486 263 487 -0.025330295874380127
R487 263 488 -0.0253302957755024
R488 263 489 -0.025330295853563965
R489 263 490 -0.02533029586976686
R490 263 491 -0.025330295869063744
R491 263 492 -0.025330295839676956
R492 263 493 -0.025330295883413047
R493 263 494 -0.025330295910565723
R494 263 495 -0.025330295910565723
R495 263 496 -0.025330295910565723
R496 263 497 -0.025330295910565723
R497 263 498 -0.025330295831415574
R498 263 499 -0.025330295910565723
R499 263 500 -0.025330295910565723
R500 263 501 -0.02533029573054032
R501 263 502 -0.025330295910565723
R502 263 503 -0.025330295829712114
R503 263 504 -0.025330295882455747
R504 263 505 -0.025330295885978134
R505 263 506 -0.025330295910565723
R506 263 507 -0.025330295910565723
R507 263 508 -0.025330295854011583
R508 263 509 -0.025330295861406043
R509 263 510 -0.025330295790961226
R510 263 511 -0.025330295910565723
R511 263 512 -0.02533029582954867
R512 263 513 -0.025330295828765156
R513 263 514 -0.025330295897915116
R514 263 515 -0.02533029565621458
R515 263 516 -0.025330295718420028
R516 263 517 -0.025330295854612276
R517 263 518 -0.025330295877960297
R518 263 519 -0.025330295889573702
R519 263 520 -0.025330295894277897
R520 263 521 -0.025330295688460576
R521 263 522 -0.02533029589258314
R522 263 523 -0.025330295910565723
R523 263 524 -0.025330295899684756
R524 263 525 -0.025330295732392965
R525 263 526 -0.02533029588463248
R526 263 527 -0.025330295811009377
R527 263 528 -0.025330295878504872
R528 263 529 -0.025330294012483268
R529 263 530 -0.025330295879096923
R530 263 531 -0.025330295910565723
R531 263 532 -0.02533029584459299
R532 263 533 -0.025330295763986783
R533 263 534 -0.02533029587292304
R534 263 535 -0.025330295745038527
R535 263 536 -0.025330295910565723
R536 263 537 -0.02533029577017699
R537 263 538 -0.0253302955602209
R538 263 539 -0.02533029577103806
R539 263 540 -0.02533029578227418
R540 263 541 -0.02533029588508009
R541 263 542 -0.025330295770924487
R542 263 543 -0.025330295772360605
R543 263 544 -0.025330295746532498
R544 263 545 -0.025330295775708923
R545 263 546 -0.02533029578350369
R546 263 547 -0.025330295856563798
R547 263 548 -0.025330295892680623
R548 263 549 -0.02533029581786732
R549 263 550 -0.025330295910565723
R550 263 551 -0.025330295910565723
R551 263 552 -0.025330295910565723
R552 263 553 -0.025330295910565723
R553 263 554 -0.025330295906415508
R554 263 555 -0.025330295880836098
R555 263 556 -0.025330295854506447
R556 263 557 -0.025330295860288544
R557 263 558 -0.025330295871300704
R558 263 559 -0.05066059182116889
R559 263 560 -0.025330295886256408
R560 263 561 -0.02533029590890745
R561 263 562 -0.025330295896723434
R562 263 563 -0.025330295910565723
R563 263 564 -0.025330295797359067
R564 263 565 -0.02533029589004489
R565 263 566 -0.025330295805073278
R566 263 567 -0.025330295746746428
R567 263 568 -0.025330295858828584
R568 263 569 -0.025330295587574703
R569 263 570 -0.025330295910565723
R570 263 571 -0.02533029585991425
R571 263 572 -0.02533029589749261
R572 263 573 -0.025330295901641268
R573 263 574 -0.02533029586367573
R574 263 575 -0.0253302958417168
R575 263 576 -0.025330295910565723
R576 263 577 -0.025330295846906326
R577 263 578 -0.025330295910565723
R578 263 579 -0.025330295699543766
R579 263 580 -0.025330295862389707
R580 263 581 -0.025330295855042647
R581 263 582 -0.025330295850240308
R582 263 583 -0.025330295837722373
R583 263 584 -0.025330295811929568
R584 263 585 -0.02533029585179486
R585 263 586 -0.025330295784347652
R586 263 587 -0.025330295910565723
R587 263 588 -0.025330295818030975
R588 263 589 -0.025330295813054144
R589 263 590 -0.025330295910565723
R590 263 591 -0.025330295099810714
R591 263 592 -0.025330295833817646
R592 263 593 -0.025330295783261136
R593 263 594 -0.025330295910565723
R594 263 595 -0.025330295910565723
R595 263 596 -0.02533029587562665
R596 263 597 -0.025330295910565723
R597 263 598 -0.0253302958728445
R598 263 599 -0.02533029584520647
R599 263 600 -0.025330295835391703
R600 263 601 -0.025330295847200462
R601 263 602 -0.025330295658628342
R602 263 603 -0.025330295910565723
R603 263 604 -0.025330295714279
R604 263 605 -0.025330295910565723
R605 263 606 -0.025330295910565723
R606 263 607 -0.025330295797259008
R607 263 608 -0.025330295910565723
R608 263 609 -0.025330295753711454
R609 263 610 -0.025330295910565723
R610 263 611 -0.025330295910565723
R611 263 612 -0.025330295910565723
R612 263 613 -0.02533029585761981
R613 263 614 -0.02533029587023204
R614 263 615 -0.025330295910565723
R615 263 616 -0.02533029558917467
R616 263 617 -0.025330295910565723
R617 263 618 -0.025330295910565723
R618 263 619 -0.025330295910565723
R619 263 620 -0.02533029586176266
R620 263 621 -0.025330292893312584
R621 263 622 -0.025330295900698015
R622 263 623 -0.02533029589041248
R623 263 624 -0.025330295718351648
R624 263 625 -0.025330295910565723
R625 263 626 -0.025330295910565723
R626 263 627 -0.05066059182116889
R627 263 628 -0.02533029581021484
R628 263 629 -0.025330295910565723
R629 263 630 -0.02533029581764415
R630 263 631 -0.025330295877393386
R631 263 632 -0.02533029579979464
R632 263 633 -0.025330295816837458
R633 263 634 -0.025330295910565723
R634 263 635 -0.02533029582336673
R635 263 636 -0.025330295889456057
R636 263 637 -0.025330295805751378
R637 263 638 -0.02533029587668717
R638 263 639 -0.025330295910565723
R639 263 640 -0.02533029590469049
R640 263 641 -0.02533029587054891
R641 263 642 -0.025330295910565723
R642 263 643 -0.025330295473148075
R643 263 644 -0.02533029587509607
R644 263 645 -0.025330295886268086
R645 263 646 -0.025330295846084525
R646 263 647 -0.02533029586042548
R647 263 648 -0.025330295897948014
R648 263 649 -0.02533029586913564
R649 263 650 -0.025330295601096415
R650 263 651 -0.02533029546085875
R651 263 652 -0.025330295867586512
R652 263 653 -0.025330295871078903
R653 263 654 -0.025330295890731516
R654 263 655 -0.025330295837880257
R655 263 656 -0.025330295858278288
R656 263 657 -0.02533029581889835
R657 263 658 -0.025330295734211344
R658 263 659 -0.025330295865410947
R659 263 660 -0.025330295907700792
R660 263 661 -0.02533029586781879
R661 263 662 -0.025330295910565723
R662 263 663 -0.025330295846134818
R663 263 664 -0.025330295732956483
R664 263 665 -0.025330295730168807
R665 263 666 -0.025330295835873814
R666 263 667 -0.02533029585747908
R667 263 668 -0.025330295872257286
R668 263 669 -0.025330295873908414
R669 263 670 -0.02533029580779338
R670 263 671 -0.025330295888182055
R671 263 672 -0.025330295837471484
R672 263 673 -0.0253302958543755
R673 263 674 -0.025330295855970585
R674 263 675 -0.025330295910565723
R675 263 676 -0.025330295672127592
R676 263 677 -0.025330295830539837
R677 263 678 -0.0253302958701472
R678 263 679 -0.025330295766126876
R679 263 680 -0.025330295853864218
R680 263 681 -0.025330295910565723
R681 263 682 -0.025330295867550996
R682 263 683 -0.025330295894867235
R683 263 684 -0.025330295895512358
R684 263 685 -0.025330295736786045
R685 263 686 -0.025330295862263253
R686 263 687 -0.025330295828389207
R687 263 688 -0.025330295801209286
R688 263 689 -0.02533029587841031
R689 263 690 -0.025330295910565723
R690 263 691 -0.025330295910565723
R691 263 692 -0.025330295769548025
R692 263 693 -0.025330295910565723
R693 263 694 -0.025330295796773903
R694 263 695 -0.025330295795368888
R695 263 696 -0.025330295836512293
R696 263 697 -0.025330295892975516
R697 263 698 -0.025330295910565723
R698 263 699 -0.025330295910565723
R699 263 700 -0.025330295820750786
R700 263 701 -0.025330295817434276
R701 263 702 -0.025330295853034108
R702 263 703 -0.025330295790191856
R703 263 704 -0.02533029575905874
R704 263 705 -0.02533029586143282
R705 263 706 -0.02533029581611586
R706 263 707 -0.02533029582079535
R707 263 708 -0.02533029590922821
R708 263 709 -0.025330295910565723
R709 263 710 -0.025330295910565723
R710 263 711 -0.025330295900786212
R711 263 712 -0.025330295753705864
R712 263 713 -0.02533029572809965
R713 263 714 -0.025330295898420813
R714 263 715 -0.025330295813208743
R715 263 716 -0.025330295783543056
R716 263 717 -0.025330295822332604
R717 263 718 -0.025330295910565723
R718 263 719 -0.025330295910565723
R719 263 720 -0.025330295910565723
R720 263 721 -0.025330295871696343
R721 263 722 -0.02533029590627741
R722 263 723 -0.025330295786088686
R723 263 724 -0.025330295886176996
R724 263 725 -0.025330295910565723
R725 263 726 -0.02533029584045234
R726 263 727 -0.02533029569138346
R727 263 728 -0.025330295841414295
R728 263 729 -0.025330295910565723
R729 263 730 -0.025330295910565723
R730 263 731 -0.025330295856665574
R731 263 732 -0.025330295884893092
R732 263 733 -0.025330286649410824
R733 263 734 -0.025330295387545682
R734 263 735 -0.025330295910565723
R735 263 736 -0.025330295797950764
R736 263 737 -0.025330295910565723
R737 263 738 -0.025330295910565723
R738 263 739 -0.025330295843172076
R739 263 740 -0.0253302958558246
R740 263 741 -0.025330295910565723
R741 263 742 -0.025330295841434283
R742 263 743 -0.025330295910565723
R743 263 744 -0.025330295872299385
R744 263 745 -0.02533029585108084
R745 263 746 -0.02533029577096036
R746 263 747 -0.025330295767263117
R747 263 748 -0.025330295777857708
R748 263 749 -0.05066059182116889
R749 263 750 -0.025330295819461078
R750 263 751 -0.025330295766065738
R751 263 752 -0.025330295910565723
R752 263 753 -0.025330295839723065
R753 263 754 -0.025330295091380715
R754 263 755 -0.025330295826259706
R755 263 756 -0.025330295803969765
R756 263 757 -0.025330295726775826
R757 263 758 -0.025330295801459905
R758 263 759 -0.025330295910565723
R759 263 760 -0.025330295809624186
R760 263 761 -0.02533029574367959
R761 263 762 -0.025330295861677083
R762 263 763 -0.025330295779909504
R763 263 764 -0.02533029586388164
R764 263 765 -0.025330295910565723
R765 263 766 -0.0253302956373813
R766 263 767 -0.025330295910565723
R767 263 768 -0.02533029587898138
R768 263 769 -0.025330295785187754
R769 263 770 -0.025330295910565723
R770 263 771 -0.025330295615142998
R771 263 772 -0.02533029582790363
R772 263 773 -0.02533029579697177
R773 263 774 -0.05066059182116889
R774 263 775 -0.025330295910565723
R775 263 776 -0.025330295856787376
R776 263 777 -0.02533029588643414
R777 263 778 -0.02533029582713365
R778 263 779 -0.025330295887636398
R779 263 780 -0.02533029565241841
R780 263 781 -0.025330295754360018
R781 263 782 -0.025330295772743712
R782 263 783 -0.02533026583471225
R783 263 784 -0.025330295894620852
R784 263 785 -0.025330295839509298
R785 263 786 -0.02533029590963916
R786 263 787 -0.025330295848981634
R787 263 788 -0.02533029588466476
R788 263 789 -0.025330295615412803
R789 263 790 -0.025330295904388456
R790 263 791 -0.025330295887813003
R791 263 792 -0.025330295855030934
R792 263 793 -0.0253302957513551
R793 263 794 -0.025330295619353602
R794 263 795 -0.02533029567293863
R795 263 796 -0.02533029571738686
R796 263 797 -0.025330295773099747
R797 263 798 -0.02533029584873548
R798 263 799 -0.025330274117432213
R799 263 800 -0.025330295798502492
R800 263 801 -0.02533029581839269
R801 263 802 -0.025330295910565723
R802 263 803 -0.025330295910565723
R803 263 804 -0.025330295766488355
R804 263 805 -0.0253302957912892
R805 263 806 -0.025330295891441187
R806 263 807 -0.025330295879119072
R807 263 808 -0.02533029582163199
R808 263 809 -0.02533029578292954
R809 263 810 -0.025330295854556924
R810 263 811 -0.025330295788687875
R811 263 812 -0.02533029589158191
R812 263 813 -0.02533029583223778
R813 263 814 -0.025330295892360164
R814 263 815 -0.025330295910565723
R815 263 816 -0.025330295869776892
R816 263 817 -0.025330295878107395
R817 263 818 -0.025330295836994428
R818 263 819 -0.025330295835804335
R819 263 820 -0.02533029587601462
R820 263 821 -0.02533029577534435
R821 263 822 -0.025330295883014827
R822 263 823 -0.025330295845943825
R823 263 824 -0.025330295898911566
R824 263 825 -0.025330295872983407
R825 263 826 -0.025330295892950824
R826 263 827 -0.025330295885909716
R827 263 828 -0.02533029588811864
R828 263 829 -0.025330295831251685
R829 263 830 -0.02533029578751494
R830 263 831 -0.02533029582064274
R831 263 832 -0.02533029583731059
R832 263 833 -0.02533029587779119
R833 263 834 -0.025330295891811436
R834 263 835 -0.02533029583201113
R835 263 836 -0.025330295835629988
R836 263 837 -0.02533029586314662
R837 263 838 -0.025330295838597857
R838 263 839 -0.025330295270659303
R839 263 840 -0.025330295910565723
R840 263 841 -0.02533029577152069
R841 263 842 -0.025330295752974
R842 263 843 -0.02533029581604848
R843 263 844 -0.02533029572562248
R844 263 845 -0.025330295763703953
R845 263 846 -0.02533029589962756
R846 263 847 -0.025330295702965393
R847 263 848 -0.025330295818822884
R848 263 849 -0.025330295808843783
R849 263 850 -0.025330295835785516
R850 263 851 -0.025330295688581535
R851 263 852 -0.025330295706757454
R852 263 853 -0.025330295884510762
R853 263 854 -0.025330295793707866
R854 263 855 -0.025330295910565723
R855 263 856 -0.025330295674202568
R856 263 857 -0.02533029585656065
R857 263 858 -0.02533029580339291
R858 263 859 -0.025330295770329008
R859 263 860 -0.02533029583976485
R860 263 861 -0.025330295829963167
R861 263 862 -0.025330295862844413
R862 263 863 -0.025330295899811197
R863 263 864 -0.02533029452761706
R864 263 865 -0.025330295892807584
R865 263 866 -0.02533029587966962
R866 263 867 -0.025330295790265567
R867 263 868 -0.02533029581693973
R868 263 869 -0.02533029587807042
R869 263 870 -0.025330295717330704
R870 263 871 -0.025330295910565723
R871 263 872 -0.02533029585585849
R872 263 873 -0.025330295772150357
R873 263 874 -0.02533029576590395
R874 263 875 -0.02533029584703364
R875 263 876 -0.02533029588222019
R876 263 877 -0.025330295769413477
R877 263 878 -0.025330295882303847
R878 263 879 -0.025330295882443402
R879 263 880 -0.025330295789152454
R880 263 881 -0.025330295877498694
R881 263 882 -0.02533029588967098
R882 263 883 -0.02533029587067442
R883 263 884 -0.02533029520439952
R884 263 885 -0.02533029580980364
R885 263 886 -0.0253302958379977
R886 263 887 -0.025330295901105943
R887 263 888 -0.025330295857649437
R888 263 889 -0.02533029589306192
R889 263 890 -0.0253302958220324
R890 263 891 -0.025330295869736515
R891 263 892 -0.02533029585003145
R892 263 893 -0.025330295891942627
R893 263 894 -0.025330295817821882
R894 263 895 -0.05066059182116889
R895 263 896 -0.025330295910565723
R896 263 897 -0.02533029583452854
R897 263 898 -0.02533029587435303
R898 263 899 -0.02533029585547197
R899 263 900 -0.025330295894495994
R900 263 901 -0.025330295880080792
R901 263 902 -0.02533029568746535
R902 263 903 -0.025330295849580894
R903 263 904 -0.025330295893916444
R904 263 905 -0.025330295807719727
R905 263 906 -0.02533029588883389
R906 263 907 -0.025330295754176863
R907 263 908 -0.025330295819404477
R908 263 909 -0.02533029581843411
R909 263 910 -0.025330295907616426
R910 263 911 -0.025330295865597385
R911 263 912 -0.02533029590234442
R912 263 913 -0.025330295026658015
R913 263 914 -0.025330295890836216
R914 263 915 -0.025330295896935213
R915 263 916 -0.025330295760269766
R916 263 917 -0.025330295863000833
R917 263 918 -0.02533029583501447
R918 263 919 -0.02533029587407833
R919 263 920 -0.025330295785969924
R920 263 921 -0.025330295872827736
R921 263 922 -0.025330295816472
R922 263 923 -0.02533029584992131
R923 263 924 -0.02533029587151263
R924 263 925 -0.025330295830095165
R925 263 926 -0.02533029588521453
R926 263 927 -0.02533029588281038
R927 263 928 -0.02533029587569062
R928 263 929 -0.02533029589079063
R929 263 930 -0.025330295857131067
R930 263 931 -0.025330295866776802
R931 263 932 -0.025330295846310105
R932 263 933 -0.025330295894273692
R933 263 934 -0.02533029580721639
R934 263 935 -0.02533029589113347
R935 263 936 -0.025330295860374507
R936 263 937 -0.025330295708375385
R937 263 938 -0.02533029588045893
R938 263 939 -0.025330295877532844
R939 263 940 -0.025330295899131806
R940 263 941 -0.02533029589124278
R941 263 942 -0.02533029578557433
R942 263 943 -0.025330295887079017
R943 263 944 -0.025330295852392194
R944 263 945 -0.02533029580343196
R945 263 946 -0.025330295892343868
R946 263 947 -0.025330295898401616
R947 263 948 -0.02533029589572074
R948 263 949 -0.025330295890522003
R949 263 950 -0.025330295891205272
R950 263 951 -0.02533029589798007
R951 263 952 -0.025330295895232557
R952 263 953 -0.025330295899491238
R953 263 954 -0.02533029589479018
R954 263 955 -0.02533029584569269
R955 263 956 -0.025330295841354895
R956 263 957 -0.025330295842318412
R957 263 958 -0.02533029585689515
R958 263 959 -0.025330295891880527
R959 263 960 -0.025330295891568537
R960 263 961 -0.025330295841312234
R961 263 962 -0.025330295898007397
R962 263 963 -0.025330295876404955
R963 263 964 -0.02533029588040639
R964 263 965 -0.025330295858487183
R965 263 966 -0.02533029590197205
R966 263 967 -0.02533029586709801
R967 263 968 -0.02533029589734002
R968 263 969 -0.025330295897646328
R969 263 970 -0.02533029589076761
R970 263 971 -0.02533029590354741
R971 263 972 -0.025330295887351872
R972 263 973 -0.025330295852933973
R973 263 974 -0.02533029587147491
R974 263 975 -0.025330295704635575
R975 263 976 -0.025330295822887806
R976 263 977 -0.025330295816071578
R977 263 978 -0.025330295774788045
R978 263 979 -0.025330295824601463
R979 263 980 -0.025330295900423745
R980 263 981 -0.025330295896772267
R981 263 982 -0.025330295862504973
R982 263 983 -0.025330295878007628
R983 263 984 -0.025330295851172215
R984 263 985 -0.02533029581369629
R985 263 986 -0.02533029590810113
R986 263 987 -0.025330295814913757
R987 263 988 -0.025330295892091365
R988 263 989 -0.02533029589841981
R989 263 990 -0.025330295878552227
R990 263 991 -0.025330295887547573
R991 263 992 -0.025330295868238224
R992 263 993 -0.02533029587087612
R993 263 994 -0.025330295836494047
R994 263 995 -0.02533029579810968
R995 263 996 -0.025330295820437436
R996 263 997 -0.025330295888865758
R997 263 998 -0.025330295874657568
R998 263 999 -0.025330295849714763
R999 263 1000 -0.02533029569657267
R1000 263 1001 -0.025330295853303254
R1001 263 1002 -0.025330295875720915
R1002 263 1003 -0.025330295840230013
R1003 263 1004 -0.025330295890126576
R1004 263 1005 -0.025330295873949586
R1005 263 1006 -0.025330295829960617
R1006 263 1007 -0.02533029577773061
R1007 263 1008 -0.025330295892778815
R1008 263 1009 -0.025330295836806262
R1009 263 1010 -0.02533029580229693
R1010 263 1011 -0.025330295903100816
R1011 263 1012 -0.025330295910565723
R1012 263 1013 -0.025330295889363346
R1013 263 1014 -0.02533029572467285
R1014 263 1015 -0.025330295902338477
R1015 263 1016 -0.02533029588869706
R1016 263 1017 -0.02533029585179441
R1017 263 1018 -0.025330295837057128
R1018 263 1019 -0.025330295872338572
R1019 263 1020 -0.025330295904045022
R1020 263 1021 -0.025330295905787295
R1021 263 1022 -0.02533029590629026
R1022 263 1023 -0.025330295901189834
R1023 263 1024 -0.025330295903933434
R1024 263 1025 -0.025330295906680858
R1025 263 1026 -0.02533029586318888
R1026 263 1027 -0.025330295895966214
R1027 263 1028 -0.025330295904248123
R1028 263 1029 -0.025330295901737975
R1029 263 1030 -0.02533029590338253
R1030 263 1031 -0.025330295900157306
R1031 263 1032 -0.025330295901614234
R1032 263 1033 -0.025330295820357944
R1033 263 1034 -0.0253302959051237
R1034 263 1035 -0.02533029589615963
R1035 263 1036 -0.025330295903403816
R1036 263 1037 -0.025330295894707144
R1037 263 1038 -0.02533029588638522
R1038 263 1039 -0.025330295878255502
R1039 263 1040 -0.025330295901646826
R1040 263 1041 -0.02533029576306154
R1041 263 1042 -0.025330295877905907
R1042 263 1043 -0.02533029589275546
R1043 263 1044 -0.025330295884160078
R1044 263 1045 -0.025330295905656816
R1045 263 1046 -0.025330295821231547
R1046 263 1047 -0.025330295886748865
R1047 263 1048 -0.02533029588777088
R1048 263 1049 -0.025330295902058906
R1049 263 1050 -0.025330295896976843
R1050 263 1051 -0.025330295846098687
R1051 263 1052 -0.025330295907381808
R1052 263 1053 -0.025330295901115935
R1053 263 1054 -0.025330295907821574
R1054 263 1055 -0.025330295902752657
R1055 263 1056 -0.025330295902076003
R1056 263 1057 -0.025330295851570633
R1057 263 1058 -0.025330295904576458
R1058 263 1059 -0.02533029590521313
R1059 263 1060 -0.025330295894842127
R1060 263 1061 -0.025330295910565723
R1061 263 1062 -0.02533029590674388
R1062 263 1063 -0.02533029590333368
R1063 263 1064 -0.025330295906569867
R1064 263 1065 -0.025330295900450755
R1065 263 1066 -0.025330295900844967
R1066 263 1067 -0.025330295868628727
R1067 263 1068 -0.0253302958992069
R1068 263 1069 -0.025330295875587633
R1069 263 1070 -0.025330295907049563
R1070 263 1071 -0.025330295897331365
R1071 263 1072 -0.025330295910565723
R1072 263 1073 -0.025330295890564784
R1073 263 1074 -0.025330295910565723
R1074 263 1075 -0.025330295894219448
R1075 263 1076 -0.025330295862764245
R1076 263 1077 -0.025330295909370866
R1077 263 1078 -0.0253302959025176
R1078 263 1079 -0.025330295905314222
R1079 263 1080 -0.02533029588610174
R1080 263 1081 -0.025330295874791738
R1081 263 1082 -0.025330295910565723
R1082 263 1083 -0.025330295880084237
R1083 263 1084 -0.025330295910565723
R1084 263 1085 -0.025330295845178034
R1085 263 1086 -0.02533029586743565
R1086 263 1087 -0.02533029586101903
R1087 263 1088 -0.025330295871282486
R1088 263 1089 -0.025330295910565723
R1089 263 1090 -0.025330295896999585
R1090 263 1091 -0.025330295870024753
R1091 263 1092 -0.025330295830942175
R1092 263 1093 -0.025330295721127664
R1093 263 1094 -0.025330295710678734
R1094 263 1095 -0.025330295694565876
R1095 263 1096 -0.025330295727885557
R1096 263 1097 -0.02533029590041977
R1097 263 1098 -0.025330295891560557
R1098 263 1099 -0.02533029588358608
R1099 263 1100 -0.025330295905859647
R1100 263 1101 -0.025330295803566626
R1101 263 1102 -0.025330295856644446
R1102 263 1103 -0.025330295903268935
R1103 263 1104 -0.02533029585265224
R1104 263 1105 -0.025330295838183817
R1105 263 1106 -0.025330295868931194
R1106 263 1107 -0.025330295803911326
R1107 263 1108 -0.025330295852601263
R1108 263 1109 -0.025330295852390536
R1109 263 1110 -0.02533029587768088
R1110 263 1111 -0.02533029582162669
R1111 263 1112 -0.025330295910565723
R1112 263 1113 -0.025330295902373255
R1113 263 1114 -0.025330295897389513
R1114 263 1115 -0.02533029585185496
R1115 263 1116 -0.025330295902239505
R1116 263 1117 -0.025330295893565204
R1117 263 1118 -0.025330295867453778
R1118 263 1119 -0.025330295894162757
R1119 263 1120 -0.025330295845773475
R1120 263 1121 -0.025330295891035796
R1121 263 1122 -0.025330295821070773
R1122 263 1123 -0.02533029587464591
R1123 263 1124 -0.025330295887075784
R1124 263 1125 -0.02533029590049821
R1125 263 1126 -0.025330295863912444
R1126 263 1127 -0.025330295854024833
R1127 263 1128 -0.025330295910565723
R1128 263 1129 -0.02533029578325685
R1129 263 1130 -0.025330295795293233
R1130 263 1131 -0.02533029586180053
R1131 263 1132 -0.025330295882842684
R1132 263 1133 -0.025330295809253753
R1133 263 1134 -0.025330295904986023
R1134 263 1135 -0.025330295864073277
R1135 263 1136 -0.02533029586540322
R1136 263 1137 -0.02533029580089623
R1137 263 1138 -0.025330295850171006
R1138 263 1139 -0.025330295725421476
R1139 263 1140 -0.025330295749873447
R1140 263 1141 -0.025330295910565723
R1141 263 1142 -0.02533029581201459
R1142 263 1143 -0.025330295831786115
R1143 263 1144 -0.025330295842540068
R1144 263 1145 -0.025330295866578728
R1145 263 1146 -0.02533029584293337
R1146 263 1147 -0.02533029580187434
R1147 263 1148 -0.025330295795103708
R1148 263 1149 -0.025330295828720973
R1149 263 1150 -0.025330295856527598
R1150 263 1151 -0.025330295873041312
R1151 263 1152 -0.025330295899438242
R1152 263 1153 -0.025330295813570637
R1153 263 1154 -0.025330295874793875
R1154 263 1155 -0.025330295807045967
R1155 263 1156 -0.025330295782590932
R1156 263 1157 -0.02533029583110305
R1157 263 1158 -0.025330295726460866
R1158 263 1159 -0.025330295784181275
R1159 263 1160 -0.025330295857961285
R1160 263 1161 -0.02533029578035557
R1161 263 1162 -0.02533029581781812
R1162 263 1163 -0.025330295868285644
R1163 263 1164 -0.025330295801254468
R1164 263 1165 -0.02533029590726214
R1165 263 1166 -0.025330295900515592
R1166 263 1167 -0.025330295828355057
R1167 263 1168 -0.025330295871212306
R1168 263 1169 -0.025330295884129255
R1169 263 1170 -0.025330295658981792
R1170 263 1171 -0.025330295896472028
R1171 263 1172 -0.02533029590251921
R1172 263 1173 -0.025330295799309895
R1173 263 1174 -0.025330295788334702
R1174 263 1175 -0.025330295871950008
R1175 263 1176 -0.025330295861343347
R1176 263 1177 -0.025330295910565723
R1177 263 1178 -0.025330295855243243
R1178 263 1179 -0.025330295837071852
R1179 263 1180 -0.02533029581700413
R1180 263 1181 -0.02533029573402271
R1181 263 1182 -0.025330295864598198
R1182 263 1183 -0.025330295910565723
R1183 263 1184 -0.025330295831385366
R1184 263 1185 -0.02533029581055377
R1185 263 1186 -0.05066059182116889
R1186 263 1187 -0.0253302958245173
R1187 263 1188 -0.025330295681989252
R1188 263 1189 -0.025330295862422247
R1189 263 1190 -0.025330295896225413
R1190 263 1191 -0.025330295733917214
R1191 263 1192 -0.025330295910565723
R1192 263 1193 -0.025330295910565723
R1193 263 1194 -0.025330295910565723
R1194 263 1195 -0.02533029587903746
R1195 263 1196 -0.02533029589298893
R1196 263 1197 -0.02533029583201045
R1197 263 1198 -0.025330295909232557
R1198 263 1199 -0.025330295836210045
R1199 263 1200 -0.02533029582898176
R1200 263 1201 -0.025330295851229048
R1201 263 1202 -0.02533029584378382
R1202 263 1203 -0.025330295852342342
R1203 263 1204 -0.02533029581997648
R1204 263 1205 -0.025330295833138918
R1205 263 1206 -0.025330295827755627
R1206 263 1207 -0.02533029583077342
R1207 263 1208 -0.02533029583559369
R1208 263 1209 -0.025330295806019996
R1209 263 1210 -0.025330295825448802
R1210 263 1211 -0.02533029584949946
R1211 263 1212 -0.025330295845202088
R1212 263 1213 -0.025330295861681534
R1213 263 1214 -0.025330295801784048
R1214 263 1215 -0.025330295713170817
R1215 263 1216 -0.025330295791870305
R1216 263 1217 -0.02533029580421128
R1217 263 1218 -0.02533029581358767
R1218 263 1219 -0.025330295841472852
R1219 263 1220 -0.025330295884820553
R1220 263 1221 -0.02533029586607638
R1221 263 1222 -0.025330295371039844
R1222 263 1223 -0.025330295741929854
R1223 263 1224 -0.025330295863121067
R1224 263 1225 -0.025330295791331302
R1225 263 1226 -0.025330295876329182
R1226 263 1227 -0.025330295795888202
R1227 263 1228 -0.025330295825891837
R1228 263 1229 -0.025330295823026757
R1229 263 1230 -0.025330295841572203
R1230 263 1231 -0.025330295865006507
R1231 263 1232 -0.02533029587412544
R1232 263 1233 -0.025330295817034967
R1233 263 1234 -0.02533029586611154
R1234 263 1235 -0.02533029585991155
R1235 263 1236 -0.025330295816655846
R1236 263 1237 -0.02533029585391657
R1237 263 1238 -0.025330295793219215
R1238 263 1239 -0.025330295872664582
R1239 263 1240 -0.025330295897960032
R1240 263 1241 -0.02533029586865022
R1241 263 1242 -0.025330295865847133
R1242 263 1243 -0.025330295849000276
R1243 263 1244 -0.0253302958740592
R1244 263 1245 -0.0253302958826435
R1245 263 1246 -0.02533029584841502
R1246 263 1247 -0.025330295857246447
R1247 263 1248 -0.02533029581400973
R1248 263 1249 -0.025330295877039454
R1249 263 1250 -0.02533029588482458
R1250 263 1251 -0.025330295875331536
R1251 263 1252 -0.025330295772945908
R1252 263 1253 -0.02533029583464211
R1253 263 1254 -0.025330295910565723
R1254 263 1255 -0.0253302957830311
R1255 263 1256 -0.025330295910565723
R1256 263 1257 -0.02533029581728963
R1257 263 1258 -0.0253302956819235
R1258 263 1259 -0.025330295829071963
R1259 263 1260 -0.025330295810526118
R1260 263 1261 -0.025330295887996526
R1261 263 1262 -0.0253302958791032
R1262 263 1263 -0.025330295835893822
R1263 263 1264 -0.025330295791929996
R1264 263 1265 -0.02533029582349954
R1265 263 1266 -0.02533029582372647
R1266 263 1267 -0.025330295910565723
R1267 263 1268 -0.02533029583224049
R1268 263 1269 -0.025330295830237864
R1269 263 1270 -0.025330295825051596
R1270 263 1271 -0.0253302958167619
R1271 263 1272 -0.025330295841389412
R1272 263 1273 -0.025330295875535064
R1273 263 1274 -0.025330295799931023
R1274 263 1275 -0.02533029584381987
R1275 263 1276 -0.025330295831213923
R1276 263 1277 -0.02533029579830478
R1277 263 1278 -0.025330295847576872
R1278 263 1279 -0.02533029587004915
R1279 263 1280 -0.025330295876466968
R1280 263 1281 -0.025330295792168625
R1281 263 1282 -0.025330295831555442
R1282 263 1283 -0.0253302958843933
R1283 263 1284 -0.02533029586135038
R1284 263 1285 -0.02533029588102463
R1285 263 1286 -0.025330295698453936
R1286 263 1287 -0.02533029577958179
R1287 263 1288 -0.02533029575243112
R1288 263 1289 -0.02533029590218912
R1289 263 1290 -0.02533029580592903
R1290 263 1291 -0.02533029581792266
R1291 263 1292 -0.02533029560770977
R1292 263 1293 -0.02533029585813143
R1293 263 1294 -0.02533029584507347
R1294 263 1295 -0.025330295817020235
R1295 263 1296 -0.025330295744483287
R1296 263 1297 -0.025330295816609602
R1297 263 1298 -0.025330295548166754
R1298 263 1299 -0.02533029585552901
R1299 263 1300 -0.02533029588912658
R1300 263 1301 -0.025330295812626018
R1301 263 1302 -0.025330295867358636
R1302 263 1303 -0.02533029573243485
R1303 263 1304 -0.025330295863893872
R1304 263 1305 -0.02533029576378502
R1305 263 1306 -0.025330295894105584
R1306 263 1307 -0.025330295773931238
R1307 263 1308 -0.025330295904363847
R1308 263 1309 -0.025330295848835515
R1309 263 1310 -0.02533029590098456
R1310 263 1311 -0.02533029589762059
R1311 263 1312 -0.02533029587451282
R1312 263 1313 -0.02533029586358483
R1313 263 1314 -0.025330295806730775
R1314 263 1315 -0.025330295858370037
R1315 263 1316 -0.02533029566169907
R1316 263 1317 -0.025330295906153523
R1317 263 1318 -0.025330295910565723
R1318 263 1319 -0.02533029585544537
R1319 263 1320 -0.025330295831998938
R1320 263 1321 -0.025330295895568004
R1321 263 1322 -0.02533029585884568
R1322 263 1323 -0.025330295809453285
R1323 263 1324 -0.025330295764540742
R1324 263 1325 -0.025330295808208315
R1325 263 1326 -0.02533029590606775
R1326 263 1327 -0.025330295902781824
R1327 263 1328 -0.025330295807551657
R1328 263 1329 -0.025330295782827528
R1329 263 1330 -0.02533029578107738
R1330 263 1331 -0.025330295813542594
R1331 263 1332 -0.02533029584865175
R1332 263 1333 -0.02533029590609373
R1333 263 1334 -0.02533029590048106
R1334 263 1335 -0.025330295910565723
R1335 263 1336 -0.02533029578863138
R1336 263 1337 -0.02533029581295811
R1337 263 1338 -0.025330295880380965
R1338 263 1339 -0.02533029585576237
R1339 263 1340 -0.025330295892068536
R1340 263 1341 -0.025330295861423987
R1341 263 1342 -0.02533029588427675
R1342 263 1343 -0.02533029589307169
R1343 263 1344 -0.025330295910565723
R1344 263 1345 -0.025330295839620164
R1345 263 1346 -0.02533029585458043
R1346 263 1347 -0.025330295804778368
R1347 263 1348 -0.025330295910565723
R1348 263 1349 -0.025330295750420166
R1349 263 1350 -0.025330295893233993
R1350 263 1351 -0.025330295844701114
R1351 263 1352 -0.02533029585382708
R1352 263 1353 -0.025330295817764678
R1353 263 1354 -0.025330295895287635
R1354 263 1355 -0.025330295896552533
R1355 263 1356 -0.02533029587006357
R1356 263 1357 -0.025330295865094707
R1357 263 1358 -0.02533029586003608
R1358 263 1359 -0.025330295848332005
R1359 263 1360 -0.025330295888955107
R1360 263 1361 -0.025330295880836642
R1361 263 1362 -0.02533029584462457
R1362 263 1363 -0.025330295898882887
R1363 263 1364 -0.025330295878950856
R1364 263 1365 -0.025330295794101683
R1365 263 1366 -0.025330295824046094
R1366 263 1367 -0.02533029584759297
R1367 263 1368 -0.025330295844848718
R1368 263 1369 -0.025330295877958806
R1369 263 1370 -0.02533029587273448
R1370 263 1371 -0.025330295859285607
R1371 263 1372 -0.025330295811551544
R1372 263 1373 -0.02533029587592228
R1373 263 1374 -0.025330295875823413
R1374 263 1375 -0.025330295884896995
R1375 263 1376 -0.025330295796828165
R1376 263 1377 -0.02533029587319895
R1377 263 1378 -0.02533029588972753
R1378 263 1379 -0.025330295870675843
R1379 263 1380 -0.025330295850333508
R1380 263 1381 -0.025330295797862508
R1381 263 1382 -0.025330295910565723
R1382 263 1383 -0.025330295877828268
R1383 263 1384 -0.025330295903360004
R1384 263 1385 -0.025330295896734915
R1385 263 1386 -0.025330295801799192
R1386 263 1387 -0.025330295834712843
R1387 263 1388 -0.025330295910565723
R1388 263 1389 -0.025330295843825137
R1389 263 1390 -0.025330295849005917
R1390 263 1391 -0.02533029586939701
R1391 263 1392 -0.025330295849613087
R1392 263 1393 -0.02533029576895007
R1393 263 1394 -0.025330295869650004
R1394 263 1395 -0.02533029588951476
R1395 263 1396 -0.025330295864522068
R1396 263 1397 -0.025330295872414085
R1397 263 1398 -0.025330295784357176
R1398 263 1399 -0.025330295841506735
R1399 263 1400 -0.025330295747268826
R1400 263 1401 -0.025330295862536458
R1401 263 1402 -0.025330295808352277
R1402 263 1403 -0.025330295775234043
R1403 263 1404 -0.025330295871985355
R1404 263 1405 -0.025330295689791144
R1405 263 1406 -0.025330295816410744
R1406 263 1407 -0.025330295842198116
R1407 263 1408 -0.025330295790207902
R1408 263 1409 -0.025330295855654286
R1409 263 1410 -0.05066059182116889
R1410 263 1411 -0.025330295887582358
R1411 263 1412 -0.025330295910565723
R1412 263 1413 -0.025330295890148388
R1413 263 1414 -0.02533029581757757
R1414 263 1415 -0.02533029573506857
R1415 263 1416 -0.025330295910565723
R1416 263 1417 -0.02533029580032754
R1417 263 1418 -0.0253302957379755
R1418 263 1419 -0.025330295869811125
R1419 263 1420 -0.025330295863154495
R1420 263 1421 -0.0253302958680363
R1421 263 1422 -0.025330295862424503
R1422 263 1423 -0.025330295910565723
R1423 263 1424 -0.025330295722959906
R1424 263 1425 -0.025330295730630503
R1425 263 1426 -0.02533029588427777
R1426 263 1427 -0.025330295865306753
R1427 263 1428 -0.025330295899278196
R1428 263 1429 -0.025330295863967213
R1429 263 1430 -0.02533029588199927
R1430 263 1431 -0.02533029589557048
R1431 263 1432 -0.025330295910565723
R1432 263 1433 -0.025330295848474058
R1433 263 1434 -0.02533029581532139
R1434 263 1435 -0.025330295107227407
R1435 263 1436 -0.0253302958018332
R1436 263 1437 -0.025330295762319637
R1437 263 1438 -0.025330295761256037
R1438 263 1439 -0.025330295910565723
R1439 263 1440 -0.025330295800936556
R1440 263 1441 -0.025330295751972605
R1441 263 1442 -0.025330295823898976
R1442 263 1443 -0.025330295892729247
R1443 263 1444 -0.025330295910565723
R1444 263 1445 -0.025330295770720906
R1445 263 1446 -0.025330295769110174
R1446 263 1447 -0.025330295910565723
R1447 263 1448 -0.025330295910565723
R1448 263 1449 -0.025330295834428158
R1449 263 1450 -0.025330295839088468
R1450 263 1451 -0.025330295910565723
R1451 263 1452 -0.025330295852723998
R1452 263 1453 -0.025330295843346822
R1453 263 1454 -0.025330295806683566
R1454 263 1455 -0.02533029589481534
R1455 263 1456 -0.025330295750457074
R1456 263 1457 -0.02533029567442149
R1457 263 1458 -0.02533029584320355
R1458 263 1459 -0.025330295891482613
R1459 263 1460 -0.02533029583568969
R1460 263 1461 -0.025330295496283812
R1461 263 1462 -0.025330295767465805
R1462 263 1463 -0.025330295647735184
R1463 263 1464 -0.025330295791119287
R1464 263 1465 -0.02533029584332223
R1465 263 1466 -0.025330295770782527
R1466 263 1467 -0.025330295857593693
R1467 263 1468 -0.02533029579938804
R1468 263 1469 -0.025330295624842042
R1469 263 1470 -0.025330295910565723
R1470 263 1471 -0.025330295847277876
R1471 263 1472 -0.025330295789802466
R1472 263 1473 -0.025330295910565723
R1473 263 1474 -0.025330295748921254
R1474 263 1475 -0.025330295910565723
R1475 263 1476 -0.02533029587725384
R1476 263 1477 -0.025330295905345582
R1477 263 1478 -0.025330295905156428
R1478 263 1479 -0.02533029575833446
R1479 263 1480 -0.025330295825313133
R1480 263 1481 -0.025330295864757577
R1481 263 1482 -0.025330295855276477
R1482 263 1483 -0.025330295836882198
R1483 263 1484 -0.02533029579366411
R1484 263 1485 -0.02533029586525059
R1485 263 1486 -0.025330295832412104
R1486 263 1487 -0.025330295910565723
R1487 263 1488 -0.025330295910565723
R1488 263 1489 -0.02533029556669815
R1489 263 1490 -0.025330295910565723
R1490 263 1491 -0.02533029576955851
R1491 263 1492 -0.02533029581613845
R1492 263 1493 -0.025330295892279094
R1493 263 1494 -0.025330295910565723
R1494 263 1495 -0.025330295910565723
R1495 263 1496 -0.025330295862874212
R1496 263 1497 -0.02533029590613766
R1497 263 1498 -0.025330295763213547
R1498 263 1499 -0.02533029580538197
R1499 263 1500 -0.02533029580070225
R1500 263 1501 -0.02533029584322596
R1501 263 1502 -0.025330295839762127
R1502 263 1503 -0.025330295614062078
R1503 263 1504 -0.025330295647936266
R1504 263 1505 -0.025330295527608074
R1505 263 1506 -0.02533029582151101
R1506 263 1507 -0.025330295791746116
R1507 263 1508 -0.025330295910565723
R1508 263 1509 -0.0253302957748081
R1509 263 1510 -0.025330295910565723
R1510 263 1511 -0.025330295595348728
R1511 263 1512 -0.025330295859994367
R1512 263 1513 -0.025330295899940784
R1513 263 1514 -0.025330295754073757
R1514 263 1515 -0.02533029588715698
R1515 263 1516 -0.025330295910565723
R1516 263 1517 -0.025330295814730796
R1517 263 1518 -0.025330295892608174
R1518 263 1519 -0.025330295860904562
R1519 263 1520 -0.025330295814677727
R1520 263 1521 -0.025330295874134934
R1521 263 1522 -0.025330295864280403
R1522 263 1523 -0.025330295890786645
R1523 263 1524 -0.025330295899706735
R1524 263 1525 -0.025330295688131277
R1525 263 1526 -0.025330295153527745
R1526 263 1527 -0.025330295848629905
R1527 263 1528 -0.025330295569593358
R1528 263 1529 -0.02533029588189279
R1529 263 1530 -0.02533029587317962
R1530 263 1531 -0.025330295826760062
R1531 263 1532 -0.025330295802304163
R1532 263 1533 -0.02533029587011626
R1533 263 1534 -0.025330295735403154
R1534 263 1535 -0.025330295887836796
R1535 263 1536 -0.025330295854911984
R1536 263 1537 -0.025330295910565723
R1537 263 1538 -0.02533029589613032
R1538 263 1539 -0.025330295696910806
R1539 263 1540 -0.025330295766922906
R1540 263 1541 -0.025330295795365304
R1541 263 1542 -0.025330295784056926
R1542 263 1543 -0.025330295822429526
R1543 263 1544 -0.02533029584924803
R1544 263 1545 -0.025330295808669724
R1545 263 1546 -0.02533029570708942
R1546 263 1547 -0.02533029584245216
R1547 263 1548 -0.025330295868450002
R1548 263 1549 -0.02533029588729718
R1549 263 1550 -0.02533029587384817
R1550 263 1551 -0.02533029584572182
R1551 263 1552 -0.025330295887628963
R1552 263 1553 -0.025330295828514968
R1553 263 1554 -0.02533029588756684
R1554 263 1555 -0.025330295769109737
R1555 263 1556 -0.02533029583732548
R1556 263 1557 -0.025330295772238998
R1557 263 1558 -0.025330295836508657
R1558 263 1559 -0.025330295875673446
R1559 263 1560 -0.025330295834258453
R1560 263 1561 -0.02533029583279302
R1561 263 1562 -0.025330295817565695
R1562 263 1563 -0.02533029589004462
R1563 263 1564 -0.025330295903934347
R1564 263 1565 -0.025330295875068902
R1565 263 1566 -0.025330295630991616
R1566 263 1567 -0.025330295838353382
R1567 263 1568 -0.025330295845847863
R1568 263 1569 -0.025330295856543915
R1569 263 1570 -0.025330295826193946
R1570 263 1571 -0.025330295836185446
R1571 263 1572 -0.025330295910565723
R1572 263 1573 -0.025330295812782427
R1573 263 1574 -0.02533029578629249
R1574 263 1575 -0.02533029572207452
R1575 263 1576 -0.025330295895260722
R1576 263 1577 -0.025330295775746636
R1577 263 1578 -0.025330295859184743
R1578 263 1579 -0.025330295815176405
R1579 263 1580 -0.025330295796192722
R1580 263 1581 -0.025330295836754408
R1581 263 1582 -0.02533029582194399
R1582 263 1583 -0.02533029588526004
R1583 263 1584 -0.025330295897106177
R1584 263 1585 -0.0253302959003476
R1585 263 1586 -0.025330295898684234
R1586 263 1587 -0.025330295834383877
R1587 263 1588 -0.02533029588938229
R1588 263 1589 -0.025330295907429967
R1589 263 1590 -0.025330295865153972
R1590 263 1591 -0.025330295893855343
R1591 263 1592 -0.025330295892965243
R1592 263 1593 -0.025330295875349424
R1593 263 1594 -0.025330295886401552
R1594 263 1595 -0.025330295869351475
R1595 263 1596 -0.025330295897232697
R1596 263 1597 -0.02533029585924482
R1597 263 1598 -0.025330295839380287
R1598 263 1599 -0.025330295773540602
R1599 263 1600 -0.025330295882474867
R1600 263 1601 -0.02533029588255686
R1601 263 1602 -0.02533029588940515
R1602 263 1603 -0.025330295841830597
R1603 263 1604 -0.02533029588630836
R1604 263 1605 -0.025330295899753733
R1605 263 1606 -0.025330295871410113
R1606 263 1607 -0.025330295888125166
R1607 263 1608 -0.02533029588144279
R1608 263 1609 -0.025330295896135314
R1609 263 1610 -0.02533029583824864
R1610 263 1611 -0.025330295765179853
R1611 263 1612 -0.02533029584257642
R1612 263 1613 -0.025330295839911126
R1613 263 1614 -0.025330295856165804
R1614 263 1615 -0.025330295845576438
R1615 263 1616 -0.02533029586987773
R1616 263 1617 -0.02533029590318891
R1617 263 1618 -0.025330295895241342
R1618 263 1619 -0.025330295860766208
R1619 263 1620 -0.025330295894519596
R1620 263 1621 -0.025330295820231465
R1621 263 1622 -0.02533029583653277
R1622 263 1623 -0.025330295816425263
R1623 263 1624 -0.025330295884305683
R1624 263 1625 -0.025330295842005263
R1625 263 1626 -0.025330295824719597
R1626 263 1627 -0.025330295888474658
R1627 263 1628 -0.025330295876243636
R1628 263 1629 -0.025330295865304206
R1629 263 1630 -0.025330295738328838
R1630 263 1631 -0.025330295874590153
R1631 263 1632 -0.0253302959020257
R1632 263 1633 -0.02533029587420419
R1633 263 1634 -0.02533029584541928
R1634 263 1635 -0.025330295867018376
R1635 263 1636 -0.025330295864846884
R1636 263 1637 -0.02533029588221678
R1637 263 1638 -0.02533029588125215
R1638 263 1639 -0.025330295910565723
R1639 263 1640 -0.025330295893981804
R1640 263 1641 -0.02533029587585971
R1641 263 1642 -0.02533029574270859
R1642 263 1643 -0.025330295829372945
R1643 263 1644 -0.025330295901482038
R1644 263 1645 -0.02533029581563643
R1645 263 1646 -0.025330295816901403
R1646 263 1647 -0.025330295910565723
R1647 263 1648 -0.02533029574970984
R1648 263 1649 -0.025330295768583883
R1649 263 1650 -0.025330295905620942
R1650 263 1651 -0.025330295870824464
R1651 263 1652 -0.025330295828737266
R1652 263 1653 -0.025330295690565576
R1653 263 1654 -0.025330295824002563
R1654 263 1655 -0.02533029575851585
R1655 263 1656 -0.025330295740056213
R1656 263 1657 -0.025330295910565723
R1657 263 1658 -0.025330295807252278
R1658 263 1659 -0.025330295910565723
R1659 263 1660 -0.025330295722709548
R1660 263 1661 -0.025330295892119162
R1661 263 1662 -0.02533029589621208
R1662 263 1663 -0.025330293248416784
R1663 263 1664 -0.025330295910565723
R1664 263 1665 -0.025330295757916142
R1665 263 1666 -0.025330295859427927
R1666 263 1667 -0.025330295786893248
R1667 263 1668 -0.025330295706320293
R1668 263 1669 -0.025330295707774255
R1669 263 1670 -0.025330295860696364
R1670 263 1671 -0.02533029568784222
R1671 263 1672 -0.025330295872307906
R1672 263 1673 -0.02533029567184402
R1673 263 1674 -0.025330295719159516
R1674 263 1675 -0.025330295862334415
R1675 263 1676 -0.02533029587508679
R1676 263 1677 -0.02533029577634995
R1677 263 1678 -0.025330295695344
R1678 263 1679 -0.02533029578228455
R1679 263 1680 -0.025330295910565723
R1680 263 1681 -0.025330295831675988
R1681 263 1682 -0.02533029578882877
R1682 263 1683 -0.025330295832204013
R1683 263 1684 -0.025330295806254854
R1684 263 1685 -0.025330295776398712
R1685 263 1686 -0.025330295910565723
R1686 263 1687 -0.025330295886344265
R1687 263 1688 -0.025330295882163244
R1688 263 1689 -0.02533029587209653
R1689 263 1690 -0.02533029561397258
R1690 263 1691 -0.025330295821085924
R1691 263 1692 -0.025330295882019817
R1692 263 1693 -0.025330295852602835
R1693 263 1694 -0.025330295779721724
R1694 263 1695 -0.025330295788436395
R1695 263 1696 -0.025330295885464874
R1696 263 1697 -0.02533029572507918
R1697 263 1698 -0.05066059182116889
R1698 263 1699 -0.025330295910565723
R1699 263 1700 -0.025330295910565723
R1700 263 1701 -0.02533029579493479
R1701 263 1702 -0.025330295897030813
R1702 263 1703 -0.02533029579988162
R1703 263 1704 -0.025330295797552277
R1704 263 1705 -0.025330295860434046
R1705 263 1706 -0.025330295660221325
R1706 263 1707 -0.025330295840523893
R1707 263 1708 -0.025330295774877897
R1708 263 1709 -0.025330295897659578
R1709 263 1710 -0.02533029577981164
R1710 263 1711 -0.02533029579412077
R1711 263 1712 -0.025330295844600507
R1712 263 1713 -0.025330295910565723
R1713 263 1714 -0.025330295769460606
R1714 263 1715 -0.025330295873895636
R1715 263 1716 -0.025330295910565723
R1716 263 1717 -0.025330295698680953
R1717 263 1718 -0.02533029583740471
R1718 263 1719 -0.025330295830159437
R1719 263 1720 -0.02533029584769826
R1720 263 1721 -0.0253302958169966
R1721 263 1722 -0.02533029588821111
R1722 263 1723 -0.025330295628498225
R1723 263 1724 -0.02533029583382196
R1724 263 1725 -0.02533029573990943
R1725 263 1726 -0.025330295712566352
R1726 263 1727 -0.025330295796061948
R1727 263 1728 -0.025330295859679174
R1728 263 1729 -0.02533029588480012
R1729 263 1730 -0.025330295893622984
R1730 263 1731 -0.025330295816504377
R1731 263 1732 -0.0253302958676655
R1732 263 1733 -0.025330295886213283
R1733 263 1734 -0.025330295887781327
R1734 263 1735 -0.02533029588569599
R1735 263 1736 -0.025330295890577302
R1736 263 1737 -0.025330295891093202
R1737 263 1738 -0.025330295899098937
R1738 263 1739 -0.025330295828973993
R1739 263 1740 -0.025330295885649542
R1740 263 1741 -0.0253302958277005
R1741 263 1742 -0.02533029581528703
R1742 263 1743 -0.025330295781202276
R1743 263 1744 -0.025330295708565594
R1744 263 1745 -0.025330295853860853
R1745 263 1746 -0.025330295889255658
R1746 263 1747 -0.02533029583152419
R1747 263 1748 -0.025330295690923293
R1748 263 1749 -0.025330295889210052
R1749 263 1750 -0.025330295877037112
R1750 263 1751 -0.025330295838925126
R1751 263 1752 -0.02533029586474497
R1752 263 1753 -0.025330295895780206
R1753 263 1754 -0.025330295825328766
R1754 263 1755 -0.025330295847217552
R1755 263 1756 -0.025330295880910066
R1756 263 1757 -0.025330295830756414
R1757 263 1758 -0.02533029588733993
R1758 263 1759 -0.025330295820818055
R1759 263 1760 -0.025330295892878767
R1760 263 1761 -0.025330295856983303
R1761 263 1762 -0.02533029587398926
R1762 263 1763 -0.025330295876391823
R1763 263 1764 -0.02533029587342138
R1764 263 1765 -0.02533029584338813
R1765 263 1766 -0.025330295876663685
R1766 263 1767 -0.025330295887667092
R1767 263 1768 -0.02533029582548254
R1768 263 1769 -0.025330295910565723
R1769 263 1770 -0.025330295910565723
R1770 263 1771 -0.0253302958626617
R1771 263 1772 -0.025330295861946763
R1772 263 1773 -0.025330295879901488
R1773 263 1774 -0.025330295886939146
R1774 263 1775 -0.025330295888267414
R1775 263 1776 -0.025330295864698496
R1776 263 1777 -0.025330295895597623
R1777 263 1778 -0.02533029585818055
R1778 263 1779 -0.025330295808310786
R1779 263 1780 -0.025330295779060933
R1780 263 1781 -0.02533029583916458
R1781 263 1782 -0.025330295867576014
R1782 263 1783 -0.02533029581040642
R1783 263 1784 -0.025330295868305548
R1784 263 1785 -0.02533029583961258
R1785 263 1786 -0.02533029573656424
R1786 263 1787 -0.02533029576740617
R1787 263 1788 -0.025330295905395765
R1788 263 1789 -0.025330295847479374
R1789 263 1790 -0.025330295804951122
R1790 263 1791 -0.025330295889972432
R1791 263 1792 -0.025330295896530786
R1792 263 1793 -0.02533029588100631
R1793 263 1794 -0.025330295818080203
R1794 263 1795 -0.025330295869494524
R1795 263 1796 -0.025330295889996086
R1796 263 1797 -0.025330295835409945
R1797 263 1798 -0.02533029574547036
R1798 263 1799 -0.025330295909390222
R1799 263 1800 -0.0253302958820111
R1800 263 1801 -0.025330295708831767
R1801 263 1802 -0.02533029589246805
R1802 263 1803 -0.02533029588871783
R1803 263 1804 -0.025330295876614645
R1804 263 1805 -0.025330295840413
R1805 263 1806 -0.025330295881102312
R1806 263 1807 -0.02533029573223213
R1807 263 1808 -0.025330295742955308
R1808 263 1809 -0.025330295910565723
R1809 263 1810 -0.025330295857861465
R1810 263 1811 -0.02533029585499062
R1811 263 1812 -0.025330295910565723
R1812 263 1813 -0.025330295910565723
R1813 263 1814 -0.025330295910565723
R1814 263 1815 -0.025330295809602943
R1815 263 1816 -0.025330295856593365
R1816 263 1817 -0.02533029590033087
R1817 263 1818 -0.025330295910565723
R1818 263 1819 -0.025330295910565723
R1819 263 1820 -0.025330295902643428
R1820 263 1821 -0.0253302956572467
R1821 263 1822 -0.025330295873335303
R1822 263 1823 -0.02533029583843839
R1823 263 1824 -0.025330295830511627
R1824 263 1825 -0.025330295878862708
R1825 263 1826 -0.025330295910565723
R1826 263 1827 -0.025330295578370823
R1827 263 1828 -0.025330295896693854
R1828 263 1829 -0.02533029588930443
R1829 263 1830 -0.025330295903453037
R1830 263 1831 -0.025330295910565723
R1831 263 1832 -0.02533029585046907
R1832 263 1833 -0.025330295864620222
R1833 263 1834 -0.025330295823842996
R1834 263 1835 -0.025330295821192186
R1835 263 1836 -0.025330295661414804
R1836 263 1837 -0.025330295910565723
R1837 263 1838 -0.025330295883966954
R1838 263 1839 -0.025330295785890286
R1839 263 1840 -0.025330295585467736
R1840 263 1841 -0.02533029588684884
R1841 263 1842 -0.025330295847462173
R1842 263 1843 -0.02533029571888682
R1843 263 1844 -0.025330295723604415
R1844 263 1845 -0.02533029583397767
R1845 263 1846 -0.02533029589415201
R1846 263 1847 -0.02533029590135896
R1847 263 1848 -0.02533029585755061
R1848 263 1849 -0.05066059182116889
R1849 263 1850 -0.025330295822672794
R1850 263 1851 -0.025330295811139186
R1851 263 1852 -0.025330295910565723
R1852 263 1853 -0.025330295910565723
R1853 263 1854 -0.025330295910565723
R1854 263 1855 -0.025330295910565723
R1855 263 1856 -0.025330295910565723
R1856 263 1857 -0.025330295910565723
R1857 263 1858 -0.025330295910565723
R1858 263 1859 -0.025330295862501708
R1859 263 1860 -0.025330295847938673
R1860 263 1861 -0.025330295871284624
R1861 263 1862 -0.025330295900048587
R1862 263 1863 -0.025330295854627864
R1863 263 1864 -0.025330295910565723
R1864 263 1865 -0.025330295910565723
R1865 263 1866 -0.025330295761049535
R1866 263 1867 -0.025330295837777957
R1867 263 1868 -0.02533029582371447
R1868 263 1869 -0.025330295910565723
R1869 263 1870 -0.025330295910565723
R1870 263 1871 -0.02533029576171091
R1871 263 1872 -0.025330295845030642
R1872 263 1873 -0.025330295796106246
R1873 263 1874 -0.025330295810580744
R1874 263 1875 -0.025330295862785547
R1875 263 1876 -0.025330295838029256
R1876 263 1877 -0.025330295840811836
R1877 263 1878 -0.025330295853065805
R1878 263 1879 -0.025330295890372334
R1879 263 1880 -0.02533029578447047
R1880 263 1881 -0.02533029576844283
R1881 263 1882 -0.025330295789609804
R1882 263 1883 -0.025330295771495585
R1883 263 1884 -0.0253302958686741
R1884 263 1885 -0.025330295860009663
R1885 263 1886 -0.025330295820095994
R1886 263 1887 -0.02533029585995048
R1887 263 1888 -0.025330295847521285
R1888 263 1889 -0.025330295899827077
R1889 263 1890 -0.02533029584269913
R1890 263 1891 -0.025330295910565723
R1891 263 1892 -0.025330295887842136
R1892 263 1893 -0.025330295888468427
R1893 263 1894 -0.025330295883180937
R1894 263 1895 -0.02533029579478127
R1895 263 1896 -0.025330295843561813
R1896 263 1897 -0.02533029586701865
R1897 263 1898 -0.02533029587915021
R1898 263 1899 -0.025330295871476196
R1899 263 1900 -0.025330295872720662
R1900 263 1901 -0.025330295874585348
R1901 263 1902 -0.025330295834170815
R1902 263 1903 -0.02533029578467697
R1903 263 1904 -0.025330295894803602
R1904 263 1905 -0.02533029590912697
R1905 263 1906 -0.02533029583919843
R1906 263 1907 -0.025330295825915426
R1907 263 1908 -0.025330295865435146
R1908 263 1909 -0.025330295686874036
R1909 263 1910 -0.025330295900706803
R1910 263 1911 -0.025330295864970556
R1911 263 1912 -0.025330295789240224
R1912 263 1913 -0.02533029588612193
R1913 263 1914 -0.02533029587965333
R1914 263 1915 -0.025330295870905153
R1915 263 1916 -0.02533029590601983
R1916 263 1917 -0.02533029588021199
R1917 263 1918 -0.025330295880245192
R1918 263 1919 -0.025330295860822718
R1919 263 1920 -0.02533029586815067
R1920 263 1921 -0.025330295881198065
R1921 263 1922 -0.02533029585949766
R1922 263 1923 -0.025330295852619825
R1923 263 1924 -0.025330295826698823
R1924 263 1925 -0.025330295834517257
R1925 263 1926 -0.02533029585105285
R1926 263 1927 -0.025330295910565723
R1927 263 1928 -0.025330295843410008
R1928 263 1929 -0.025330295898569725
R1929 263 1930 -0.02533029588063034
R1930 263 1931 -0.025330295803583792
R1931 263 1932 -0.025330295836811387
R1932 263 1933 -0.025330295868887687
R1933 263 1934 -0.025330295884720723
R1934 263 1935 -0.025330295781059074
R1935 263 1936 -0.025330295886039737
R1936 263 1937 -0.025330295829702497
R1937 263 1938 -0.025330295890127513
R1938 263 1939 -0.025330295825829043
R1939 263 1940 -0.02533029574172237
R1940 263 1941 -0.025330295853508558
R1941 263 1942 -0.025330295879615487
R1942 263 1943 -0.025330295904737635
R1943 263 1944 -0.02533029588216528
R1944 263 1945 -0.02533029568705697
R1945 263 1946 -0.025330295781977274
R1946 263 1947 -0.025330295825320457
R1947 263 1948 -0.025330295878911332
R1948 263 1949 -0.025330295827462015
R1949 263 1950 -0.025330295836895306
R1950 263 1951 -0.02533029588129751
R1951 263 1952 -0.025330295836789158
R1952 263 1953 -0.025330295839079007
R1953 263 1954 -0.02533029583126766
R1954 263 1955 -0.025330295823479593
R1955 263 1956 -0.025330295878367288
R1956 263 1957 -0.025330295829245394
R1957 263 1958 -0.025330295854613844
R1958 263 1959 -0.025330295841121817
R1959 263 1960 -0.025330295895836963
R1960 263 1961 -0.025330295871102634
R1961 263 1962 -0.0253302958855564
R1962 263 1963 -0.025330295772535708
R1963 263 1964 -0.025330295753253587
R1964 263 1965 -0.025330295807455588
R1965 263 1966 -0.025330295910565723
R1966 263 1967 -0.025330295910565723
R1967 263 1968 -0.025330295902713212
R1968 263 1969 -0.02533029587471186
R1969 263 1970 -0.025330295902008575
R1970 263 1971 -0.02533029588724205
R1971 263 1972 -0.025330295846344705
R1972 263 1973 -0.025330295626096448
R1973 263 1974 -0.02533029577514893
R1974 263 1975 -0.025330295779869096
R1975 263 1976 -0.025330295910565723
R1976 263 1977 -0.025330295869544762
R1977 263 1978 -0.025330295888761126
R1978 263 1979 -0.02533029586556788
R1979 263 1980 -0.02533029582951753
R1980 263 1981 -0.025330295864203174
R1981 263 1982 -0.025330295850502896
R1982 263 1983 -0.025330295887236003
R1983 263 1984 -0.025330295866885528
R1984 263 1985 -0.025330295881186866
R1985 263 1986 -0.025330295895959084
R1986 263 1987 -0.02533029585386841
R1987 263 1988 -0.02533029583259461
R1988 263 1989 -0.025330295022554485
R1989 263 1990 -0.025330295910565723
R1990 263 1991 -0.025330295896785895
R1991 263 1992 -0.025330295877035888
R1992 263 1993 -0.025330295865983836
R1993 263 1994 -0.02533029511087391
R1994 263 1995 -0.02533029580314077
R1995 263 1996 -0.02533029584866494
R1996 263 1997 -0.025330295820596115
R1997 263 1998 -0.025330295876464955
R1998 263 1999 -0.025330295894222643
R1999 263 2000 -0.02533029586506635
R2000 263 2001 -0.025330295852089176
R2001 263 2002 -0.025330295877341775
R2002 263 2003 -0.02533029589714305
R2003 263 2004 -0.025330295856515337
R2004 263 2005 -0.02533029585833775
R2005 263 2006 -0.025330295801899872
R2006 263 2007 -0.025330295811923833
R2007 263 2008 -0.025330295833877293
R2008 263 2009 -0.025330295903507334
R2009 263 2010 -0.025330295864082863
R2010 263 2011 -0.025330295895611716
R2011 263 2012 -0.025330295838607114
R2012 263 2013 -0.025330295809826275
R2013 263 2014 -0.02533029584703339
R2014 263 2015 -0.025330295910565723
R2015 263 2016 -0.025330295910565723
R2016 263 2017 -0.025330295910565723
R2017 263 2018 -0.025330295895692367
R2018 263 2019 -0.025330295910565723
R2019 263 2020 -0.02533029588287942
R2020 263 2021 -0.025330295828787375
R2021 263 2022 -0.025330295865558985
R2022 263 2023 -0.025330295707651378
R2023 263 2024 -0.025330295888376802
R2024 263 2025 -0.02533029586526741
R2025 263 2026 -0.025330295758737843
R2026 263 2027 -0.025330295893406893
R2027 263 2028 -0.025330295887029782
R2028 263 2029 -0.02533029588746509
R2029 263 2030 -0.025330295910565723
R2030 263 2031 -0.025330295846621647
R2031 263 2032 -0.025330295903160164
R2032 263 2033 -0.02533029590070236
R2033 263 2034 -0.025330295897137103
R2034 263 2035 -0.025330295846145753
R2035 263 2036 -0.02533029589323097
R2036 263 2037 -0.025330295853945955
R2037 263 2038 -0.025330295910565723
R2038 263 2039 -0.025330295898895693
R2039 263 2040 -0.025330295880391183
R2040 263 2041 -0.025330295816041935
R2041 263 2042 -0.02533029576544044
R2042 263 2043 -0.025330295898328192
R2043 263 2044 -0.025330295799655917
R2044 263 2045 -0.025330295841293957
R2045 263 2046 -0.025330295886748993
R2046 263 2047 -0.02533029589857527
R2047 263 2048 -0.025330295862770663
R2048 263 2049 -0.025330295820736502
R2049 263 2050 -0.025330295910565723
R2050 263 2051 -0.025330295910565723
R2051 263 2052 -0.025330295827730782
R2052 263 2053 -0.02533029586839382
R2053 263 2054 -0.025330295887245672
R2054 263 2055 -0.025330295816773696
R2055 263 2056 -0.025330295910565723
R2056 263 2057 -0.025330295897233686
R2057 263 2058 -0.025330295878758794
R2058 263 2059 -0.025330295901335082
R2059 263 2060 -0.025330295844900288
R2060 263 2061 -0.02533029566042637
R2061 263 2062 -0.02533029549103091
R2062 263 2063 -0.025330295888454757
R2063 263 2064 -0.025330295877562265
R2064 263 2065 -0.025330295875653594
R2065 263 2066 -0.0253302958879383
R2066 263 2067 -0.025330295877995197
R2067 263 2068 -0.025330295777882268
R2068 263 2069 -0.025330295910565723
R2069 263 2070 -0.025330295910565723
R2070 263 2071 -0.02533029583716475
R2071 263 2072 -0.025330295910565723
R2072 263 2073 -0.025330295816067116
R2073 263 2074 -0.025330295760326887
R2074 263 2075 -0.025330295899257758
R2075 263 2076 -0.02533029573848087
R2076 263 2077 -0.025330295910565723
R2077 263 2078 -0.025330295910565723
R2078 263 2079 -0.025330295848042375
R2079 263 2080 -0.025330295877322908
R2080 263 2081 -0.025330295883983042
R2081 263 2082 -0.025330295888460932
R2082 263 2083 -0.02533029589918466
R2083 263 2084 -0.0253302955429363
R2084 263 2085 -0.02533029589383302
R2085 263 2086 -0.02533029586877465
R2086 263 2087 -0.025330295849812782
R2087 263 2088 -0.02533029584128889
R2088 263 2089 -0.025330295872971167
R2089 263 2090 -0.02533029588062208
R2090 263 2091 -0.025330295898831
R2091 263 2092 -0.025330295848656197
R2092 263 2093 -0.025330295844870458
R2093 263 2094 -0.025330295879713673
R2094 263 2095 -0.025330295773553925
R2095 263 2096 -0.025330295861880365
R2096 263 2097 -0.025330295878957715
R2097 263 2098 -0.025330295866054
R2098 263 2099 -0.02533029586903215
R2099 263 2100 -0.025330295861424643
R2100 263 2101 -0.025330295864929565
R2101 263 2102 -0.02533029588740933
R2102 263 2103 -0.025330295798382415
R2103 263 2104 -0.025330295750619243
R2104 263 2105 -0.025330295887265396
R2105 263 2106 -0.025330295831409055
R2106 263 2107 -0.02533029589726955
R2107 263 2108 -0.025330295856757227
R2108 263 2109 -0.025330295860407775
R2109 263 2110 -0.025330295903236228
R2110 263 2111 -0.02533029588156336
R2111 263 2112 -0.02533029588876101
R2112 263 2113 -0.025330295869815323
R2113 263 2114 -0.025330295864128664
R2114 263 2115 -0.025330295827350954
R2115 263 2116 -0.02533029587612397
R2116 263 2117 -0.02533029589406962
R2117 263 2118 -0.025330295902116925
R2118 263 2119 -0.025330295884551057
R2119 263 2120 -0.025330295875607586
R2120 263 2121 -0.0253302958753552
R2121 263 2122 -0.025330295893028845
R2122 263 2123 -0.025330295910565723
R2123 263 2124 -0.02533029589507716
R2124 263 2125 -0.02533029587454532
R2125 263 2126 -0.02533029586421741
R2126 263 2127 -0.02533029585688797
R2127 263 2128 -0.025330295814059996
R2128 263 2129 -0.02533029584206306
R2129 263 2130 -0.025330295888497834
R2130 263 2131 -0.025330295830703887
R2131 263 2132 -0.025330295896193938
R2132 263 2133 -0.025330295893075408
R2133 263 2134 -0.025330295889534667
R2134 263 2135 -0.025330295876273806
R2135 263 2136 -0.025330295854922483
R2136 263 2137 -0.02533029587072104
R2137 263 2138 -0.02533029586014684
R2138 263 2139 -0.025330295766615843
R2139 263 2140 -0.025330295892462426
R2140 263 2141 -0.025330295910565723
R2141 263 2142 -0.025330295816070044
R2142 263 2143 -0.02533029581515123
R2143 263 2144 -0.025330295693364903
R2144 263 2145 -0.025330295806854926
R2145 263 2146 -0.025330295817505774
R2146 263 2147 -0.02533029583779265
R2147 263 2148 -0.025330295897976793
R2148 263 2149 -0.025330295910565723
R2149 263 2150 -0.025330295880166477
R2150 263 2151 -0.025330295859246146
R2151 263 2152 -0.025330295824032657
R2152 263 2153 -0.025330295910565723
R2153 263 2154 -0.02533029589855671
R2154 263 2155 -0.025330295859491384
R2155 263 2156 -0.025330295241565135
R2156 263 2157 -0.025330295877346504
R2157 263 2158 -0.02533029583763249
R2158 263 2159 -0.025330295898296926
R2159 263 2160 -0.025330295879951878
R2160 263 2161 -0.02533029584425631
R2161 263 2162 -0.02533029583840151
R2162 263 2163 -0.025330295910565723
R2163 263 2164 -0.025330295910565723
R2164 263 2165 -0.025330295890646424
R2165 263 2166 -0.025330295897214243
R2166 263 2167 -0.025330295903404423
R2167 263 2168 -0.025330295874547187
R2168 263 2169 -0.025330295891923843
R2169 263 2170 -0.025330295899858808
R2170 263 2171 -0.025330295895553953
R2171 263 2172 -0.025330295746784196
R2172 263 2173 -0.0253302958923638
R2173 263 2174 -0.025330295897977292
R2174 263 2175 -0.025330295890197252
R2175 263 2176 -0.025330295892511234
R2176 263 2177 -0.02533029588717527
R2177 263 2178 -0.025330295906923393
R2178 263 2179 -0.0253302957925458
R2179 263 2180 -0.025330295747889427
R2180 263 2181 -0.025330295877147895
R2181 263 2182 -0.05066059182116889
R2182 263 2183 -0.025330295887199712
R2183 263 2184 -0.025330295850069295
R2184 263 2185 -0.0253302958978751
R2185 263 2186 -0.025330295881974597
R2186 263 2187 -0.025330295904030395
R2187 263 2188 -0.02533029589050982
R2188 263 2189 -0.02533029589336027
R2189 263 2190 -0.025330295881407332
R2190 263 2191 -0.025330295890320532
R2191 263 2192 -0.0253302958553286
R2192 263 2193 -0.02533029589993267
R2193 263 2194 -0.025330295905054544
R2194 263 2195 -0.02533029571868626
R2195 263 2196 -0.02533029585034358
R2196 263 2197 -0.025330295910565723
R2197 263 2198 -0.02533029586362237
R2198 263 2199 -0.02533029582002573
R2199 263 2200 -0.025330294827388137
R2200 263 2201 -0.025330295865552306
R2201 263 2202 -0.02533029585286928
R2202 263 2203 -0.025330295844681827
R2203 263 2204 -0.025330295851671094
R2204 263 2205 -0.025330295893628643
R2205 263 2206 -0.025330295765530992
R2206 263 2207 -0.025330295900559522
R2207 263 2208 -0.025330295884159876
R2208 263 2209 -0.025330295700012696
R2209 263 2210 -0.02533029569325605
R2210 263 2211 -0.025330295701394587
R2211 263 2212 -0.02533029569530619
R2212 263 2213 -0.025330295573718867
R2213 263 2214 -0.025330295583127424
R2214 263 2215 -0.025330295717239864
R2215 263 2216 -0.02533029572058781
R2216 263 2217 -0.025330295704943027
R2217 263 2218 -0.025330295690513708
R2218 263 2219 -0.025330295692855064
R2219 263 2220 -0.02533029567072356
R2220 263 2221 -0.025330295660625973
R2221 263 2222 -0.02533029571409622
R2222 263 2223 -0.025330295698716355
R2223 263 2224 -0.025330295855537806
R2224 263 2225 -0.025330295896116434
R2225 263 2226 -0.025330295864770487
R2226 263 2227 -0.02533029590361717
R2227 263 2228 -0.025330295878274258
R2228 263 2229 -0.025330295899667888
R2229 263 2230 -0.02533029587707429
R2230 263 2231 -0.02533029587460075
R2231 263 2232 -0.025330295766821862
R2232 263 2233 -0.025330295872189334
R2233 263 2234 -0.025330295906208052
R2234 263 2235 -0.025330295907410164
R2235 263 2236 -0.025330295909309596
R2236 263 2237 -0.02533029590316297
R2237 263 2238 -0.025330295909550434
R2238 263 2239 -0.025330295905107027
R2239 263 2240 -0.025330295909597556
R2240 263 2241 -0.025330295909816603
R2241 263 2242 -0.025330295904898766
R2242 263 2243 -0.025330295909956457
R2243 263 2244 -0.025330295775235573
R2244 263 2245 -0.02533029567676562
R2245 263 2246 -0.02533029587358535
R2246 263 2247 -0.025330295892844336
R2247 263 2248 -0.02533029584568891
R2248 263 2249 -0.025330295871832522
R2249 263 2250 -0.025330290596996572
R2250 263 2251 -0.025330295902689568
R2251 263 2252 -0.025330295871565166
R2252 263 2253 -0.02533029585002474
R2253 263 2254 -0.025330295898200995
R2254 263 2255 -0.025330295863575922
R2255 263 2256 -0.025330295883066498
R2256 263 2257 -0.025330295815350408
R2257 263 2258 -0.025330295873443435
R2258 263 2259 -0.025330295894151617
R2259 263 2260 -0.025330293560904063
R2260 263 2261 -0.025330295757342813
R2261 263 2262 -0.02533029579881147
R2262 263 2263 -0.025330295690185436
R2263 263 2264 -0.025330295809080767
R2264 263 2265 -0.02533029588068163
R2265 263 2266 -0.025330295858454734
R2266 263 2267 -0.025330295875783716
R2267 263 2268 -0.025330295859405105
R2268 263 2269 -0.02533029587195392
R2269 263 2270 -0.025330295874797296
R2270 263 2271 -0.025330295837387332
R2271 263 2272 -0.025330295739327182
R2272 263 2273 -0.025330294776330437
R2273 263 2274 -0.025330295819886935
R2274 263 2275 -0.025330295878420412
R2275 263 2276 -0.025330295910565723
R2276 263 2277 -0.025330295780707973
R2277 263 2278 -0.02533029584317314
R2278 263 2279 -0.025330295881513813
R2279 263 2280 -0.025330295853367407
R2280 263 2281 -0.02533029576943029
R2281 263 2282 -0.02533029589263952
R2282 263 2283 -0.025330295827551377
R2283 263 2284 -0.025330295847210665
R2284 263 2285 -0.025330295811618102
R2285 263 2286 -0.02533029567259017
R2286 263 2287 -0.025330295910565723
R2287 263 2288 -0.025330295813917967
R2288 263 2289 -0.025330295820346054
R2289 263 2290 -0.025330295856858573
R2290 263 2291 -0.025330295842413992
R2291 263 2292 -0.025330295817033482
R2292 263 2293 -0.025330295834834822
R2293 263 2294 -0.025330295813593074
R2294 263 2295 -0.025330295858832196
R2295 263 2296 -0.05066059182116889
R2296 263 2297 -0.025330295897149323
R2297 263 2298 -0.025330295731664704
R2298 263 2299 -0.025330294729721346
R2299 263 2300 -0.025330295786463453
R2300 263 2301 -0.025330295785044275
R2301 263 2302 -0.02533029585904527
R2302 263 2303 -0.025330295825549392
R2303 263 2304 -0.025330295802357183
R2304 263 2305 -0.025330295910565723
R2305 263 2306 -0.02533029586326302
R2306 263 2307 -0.025330295745613747
R2307 263 2308 -0.02533029587293516
R2308 263 2309 -0.025330295791009264
R2309 263 2310 -0.025330295772075212
R2310 263 2311 -0.025330295637533803
R2311 263 2312 -0.025330295849379337
R2312 263 2313 -0.02533029574888649
R2313 263 2314 -0.025330295875465043
R2314 263 2315 -0.025330295881001032
R2315 263 2316 -0.025330295903407556
R2316 263 2317 -0.025330295909592918
R2317 263 2318 -0.02533029582960886
R2318 263 2319 -0.02533029587857483
R2319 263 2320 -0.025330295794270256
R2320 263 2321 -0.02533029585864131
R2321 263 2322 -0.02533029588846151
R2322 263 2323 -0.0253302958535585
R2323 263 2324 -0.025330295716017304
R2324 263 2325 -0.025330295818235093
R2325 263 2326 -0.025330295881172717
R2326 263 2327 -0.025330295729370473
R2327 263 2328 -0.02533029586721147
R2328 263 2329 -0.025330295767692062
R2329 263 2330 -0.025330295823363498
R2330 263 2331 -0.02533029561875368
R2331 263 2332 -0.025330295910565723
R2332 263 2333 -0.02533029580519446
R2333 263 2334 -0.025330295820366108
R2334 263 2335 -0.02533029588756057
R2335 263 2336 -0.025330295737953236
R2336 263 2337 -0.02533029568718054
R2337 263 2338 -0.025330295910565723
R2338 263 2339 -0.025330295877044905
R2339 263 2340 -0.02533029584816527
R2340 263 2341 -0.02533029581914226
R2341 263 2342 -0.025330295829296877
R2342 263 2343 -0.025330295661825507
R2343 263 2344 -0.025330295853775078
R2344 263 2345 -0.025330295799912635
R2345 263 2346 -0.02533029584530768
R2346 263 2347 -0.02533029549405538
R2347 263 2348 -0.025330295852102804
R2348 263 2349 -0.025330295808591977
R2349 263 2350 -0.025330295809050513
R2350 263 2351 -0.02533029581485909
R2351 263 2352 -0.025330295813327502
R2352 263 2353 -0.025330295754982184
R2353 263 2354 -0.025330295881936398
R2354 263 2355 -0.025330295858219144
R2355 263 2356 -0.02533029585048462
R2356 263 2357 -0.02533029588073626
R2357 263 2358 -0.025330295852296656
R2358 263 2359 -0.025330295896737794
R2359 263 2360 -0.025330295827024563
R2360 263 2361 -0.025330295828955723
R2361 263 2362 -0.025330295885004142
R2362 263 2363 -0.025330295824670654
R2363 263 2364 -0.02533029584238025
R2364 263 2365 -0.025330295901464628
R2365 263 2366 -0.02533029585604778
R2366 263 2367 -0.025330295847764604
R2367 263 2368 -0.02533029589189185
R2368 263 2369 -0.025330295883262216
R2369 263 2370 -0.025330295910565723
R2370 263 2371 -0.025330295889583822
R2371 263 2372 -0.025330295910565723
R2372 263 2373 -0.025330295874988296
R2373 263 2374 -0.025330295715693316
R2374 263 2375 -0.02533026631336844
R2375 263 2376 -0.02533029586421927
R2376 263 2377 -0.025330295842694694
R2377 263 2378 -0.025330295910565723
R2378 263 2379 -0.025330295790226512
R2379 263 2380 -0.025330295910565723
R2380 263 2381 -0.0253302957134722
R2381 263 2382 -0.025330295910565723
R2382 263 2383 -0.025330295881311443
R2383 263 2384 -0.02533029585212907
R2384 263 2385 -0.025330295891761424
R2385 263 2386 -0.025330295798142194
R2386 263 2387 -0.02533029581400294
R2387 263 2388 -0.025330295860217844
R2388 263 2389 -0.025330295871884366
R2389 263 2390 -0.025330295887843624
R2390 263 2391 -0.025330295882433223
R2391 263 2392 -0.025330295887726756
R2392 263 2393 -0.025330295689989145
R2393 263 2394 -0.025330294744746667
R2394 263 2395 -0.025330295830884017
R2395 263 2396 -0.025330295910565723
R2396 263 2397 -0.02533029582518848
R2397 263 2398 -0.02533029534963518
R2398 263 2399 -0.025330295886839847
R2399 263 2400 -0.025330295885462043
R2400 263 2401 -0.025330295878606985
R2401 263 2402 -0.025330295882565666
R2402 263 2403 -0.025330295777610663
R2403 263 2404 -0.025330295846457906
R2404 263 2405 -0.02533029582046152
R2405 263 2406 -0.02533029577646064
R2406 263 2407 -0.02533029563532113
R2407 263 2408 -0.025330295816397886
R2408 263 2409 -0.025330295885653775
R2409 263 2410 -0.025330295889541617
R2410 263 2411 -0.025330295817288264
R2411 263 2412 -0.025330295879577178
R2412 263 2413 -0.025330295758911263
R2413 263 2414 -0.025330295863025043
R2414 263 2415 -0.02533029589900016
R2415 263 2416 -0.025330295910565723
R2416 263 2417 -0.05066059182116889
R2417 263 2418 -0.025330295866663723
R2418 263 2419 -0.025330295850289796
R2419 263 2420 -0.025330295866025865
R2420 263 2421 -0.025330294855618465
R2421 263 2422 -0.025330295641538273
R2422 263 2423 -0.025330295549544364
R2423 263 2424 -0.025330295857769965
R2424 263 2425 -0.025330295910565723
R2425 263 2426 -0.02533029581938169
R2426 263 2427 -0.02533029572564112
R2427 263 2428 -0.02533029568571528
R2428 263 2429 -0.025330295892675634
R2429 263 2430 -0.025330295715998537
R2430 263 2431 -0.02533029588337813
R2431 263 2432 -0.025330294715982842
R2432 263 2433 -0.025330295812642647
R2433 263 2434 -0.025330295846933613
R2434 263 2435 -0.025330295802676216
R2435 263 2436 -0.05066059182116889
R2436 263 2437 -0.025330295866007393
R2437 263 2438 -0.02533029590435193
R2438 263 2439 -0.0253302958940991
R2439 263 2440 -0.02533029586710266
R2440 263 2441 -0.02533029589271091
R2441 263 2442 -0.025330295864941944
R2442 263 2443 -0.025330294907774907
R2443 263 2444 -0.02533029574250829
R2444 263 2445 -0.025330295862693492
R2445 263 2446 -0.02533029584847495
R2446 263 2447 -0.025330295723929693
R2447 263 2448 -0.025330295833322487
R2448 263 2449 -0.025330295848272618
R2449 263 2450 -0.0253302958753965
R2450 263 2451 -0.025330295910565723
R2451 263 2452 -0.025330295910565723
R2452 263 2453 -0.0253302958513745
R2453 263 2454 -0.02533029577328162
R2454 263 2455 -0.02533029586205777
R2455 263 2456 -0.025330295842289543
R2456 263 2457 -0.025330295869072893
R2457 263 2458 -0.025330295886067392
R2458 263 2459 -0.025330295854461504
R2459 263 2460 -0.025330295840845576
R2460 263 2461 -0.025330295833432097
R2461 263 2462 -0.02533029588485179
R2462 263 2463 -0.02533029587701502
R2463 263 2464 -0.025330295883249882
R2464 263 2465 -0.025330295853004493
R2465 263 2466 -0.02533029588070341
R2466 263 2467 -0.025330295779140654
R2467 263 2468 -0.02533029587343938
R2468 263 2469 -0.02533029588179664
R2469 263 2470 -0.025330295888953382
R2470 263 2471 -0.025330295880284025
R2471 263 2472 -0.02533029585004996
R2472 263 2473 -0.025330295799193655
R2473 263 2474 -0.025330295872189334
R2474 263 2475 -0.025330295815361784
R2475 263 2476 -0.025330295738734285
R2476 263 2477 -0.025330295804198717
R2477 263 2478 -0.025330295279603912
R2478 263 2479 -0.025330295876880817
R2479 263 2480 -0.025330295817243637
R2480 263 2481 -0.025330295857215905
R2481 263 2482 -0.025330295875285597
R2482 263 2483 -0.025330295872088557
R2483 263 2484 -0.02533029579106444
R2484 263 2485 -0.025330295849165088
R2485 263 2486 -0.025330295910565723
R2486 263 2487 -0.025330295890192835
R2487 263 2488 -0.02533029590521784
R2488 263 2489 -0.025330295897157115
R2489 263 2490 -0.025330295892266413
R2490 263 2491 -0.025330295890552405
R2491 263 2492 -0.025330295892188867
R2492 263 2493 -0.025330295882741122
R2493 263 2494 -0.02533029590580684
R2494 263 2495 -0.025330295876912504
R2495 263 2496 -0.025330295882919684
R2496 263 2497 -0.025330295884765493
R2497 263 2498 -0.025330295867494135
R2498 263 2499 -0.025330295866315702
R2499 263 2500 -0.02533029588832489
R2500 263 2501 -0.02533029590916902
R2501 263 2502 -0.025330295890930936
R2502 263 2503 -0.025330295910565723
R2503 263 2504 -0.025330295891726168
R2504 263 2505 -0.025330295879034806
R2505 263 2506 -0.025330295895389796
R2506 263 2507 -0.025330295895972747
R2507 263 2508 -0.02533029589300848
R2508 263 2509 -0.02533029585732161
R2509 263 2510 -0.02533029588290341
R2510 263 2511 -0.025330295900557936
R2511 263 2512 -0.025330295890837018
R2512 263 2513 -0.025330295899826646
R2513 263 2514 -0.025330295892254523
R2514 263 2515 -0.02533029589002508
R2515 263 2516 -0.025330295901577357
R2516 263 2517 -0.025330295887926055
R2517 263 2518 -0.02533029589622386
R2518 263 2519 -0.025330295886583865
R2519 263 2520 -0.025330295899323948
R2520 263 2521 -0.025330295860083205
R2521 263 2522 -0.02533029578693615
R2522 263 2523 -0.025330295901042105
R2523 263 2524 -0.025330295897179257
R2524 263 2525 -0.025330295883297084
R2525 263 2526 -0.025330295896417207
R2526 263 2527 -0.025330295892446456
R2527 263 2528 -0.025330295894605472
R2528 263 2529 -0.025330295899568478
R2529 263 2530 -0.025330295894136923
R2530 263 2531 -0.025330295896809973
R2531 263 2532 -0.025330295882986572
R2532 263 2533 -0.02533029589431232
R2533 263 2534 -0.025330295896509408
R2534 263 2535 -0.025330295893560298
R2535 263 2536 -0.025330295887585303
R2536 263 2537 -0.025330295894776665
R2537 263 2538 -0.02533029590041217
R2538 263 2539 -0.02533029589754659
R2539 263 2540 -0.02533029589753571
R2540 263 2541 -0.025330295896036522
R2541 263 2542 -0.02533029589756775
R2542 263 2543 -0.025330295898772517
R2543 263 2544 -0.025330295900068096
R2544 263 2545 -0.025330295902454426
R2545 263 2546 -0.025330295895844426
R2546 263 2547 -0.02533029589861522
R2547 263 2548 -0.025330295897130106
R2548 263 2549 -0.025330295891433464
R2549 263 2550 -0.025330295896864304
R2550 263 2551 -0.025330295891022377
R2551 263 2552 -0.025330295910565723
R2552 263 2553 -0.02533029587856809
R2553 263 2554 -0.025330295908251355
R2554 263 2555 -0.025330295897043584
R2555 263 2556 -0.025330295904362293
R2556 263 2557 -0.025330295905723756
R2557 263 2558 -0.025330295906676722
R2558 263 2559 -0.02533029590187842
R2559 263 2560 -0.02533029583398682
R2560 263 2561 -0.025330295905271846
R2561 263 2562 -0.02533029590744294
R2562 263 2563 -0.02533029587267987
R2563 263 2564 -0.025330295893363858
R2564 263 2565 -0.025330295884391726
R2565 263 2566 -0.025330295908650248
R2566 263 2567 -0.025330295910565723
R2567 263 2568 -0.025330295885804162
R2568 263 2569 -0.025330295889936003
R2569 263 2570 -0.025330295904884503
R2570 263 2571 -0.025330295898174024
R2571 263 2572 -0.02533029582726852
R2572 263 2573 -0.025330295886146877
R2573 263 2574 -0.025330295806847695
R2574 263 2575 -0.02533029590069285
R2575 263 2576 -0.025330295896287394
R2576 263 2577 -0.025330295878245642
R2577 263 2578 -0.025330295852275336
R2578 263 2579 -0.025330295736624122
R2579 263 2580 -0.025330295822064385
R2580 263 2581 -0.025330295827436993
R2581 263 2582 -0.025330295759338817
R2582 263 2583 -0.025330295827173395
R2583 263 2584 -0.025330295818823633
R2584 263 2585 -0.025330295743930975
R2585 263 2586 -0.025330295776826
R2586 263 2587 -0.025330295814917567
R2587 263 2588 -0.025330295819212888
R2588 263 2589 -0.025330295829544075
R2589 263 2590 -0.0253302958238752
R2590 263 2591 -0.025330295826190802
R2591 263 2592 -0.025330295744076043
R2592 263 2593 -0.025330295818252413
R2593 263 2594 -0.02533029584663365
R2594 263 2595 -0.02533029582490426
R2595 263 2596 -0.02533029581721798
R2596 263 2597 -0.02533029582605972
R2597 263 2598 -0.025330295816995793
R2598 263 2599 -0.025330295824552606
R2599 263 2600 -0.025330295816889527
R2600 263 2601 -0.0253302958109279
R2601 263 2602 -0.025330295831768553
R2602 263 2603 -0.02533029582872494
R2603 263 2604 -0.02533029583854608
R2604 263 2605 -0.02533029581548863
R2605 263 2606 -0.025330295838689253
R2606 263 2607 -0.02533029581488571
R2607 263 2608 -0.02533029582781906
R2608 263 2609 -0.025330295835003687
R2609 263 2610 -0.025330295829609446
R2610 263 2611 -0.02533029582786055
R2611 263 2612 -0.025330295828761562
R2612 263 2613 -0.025330295838865632
R2613 263 2614 -0.02533029581679469
R2614 263 2615 -0.025330295831604382
R2615 263 2616 -0.02533029583369243
R2616 263 2617 -0.02533029583528987
R2617 263 2618 -0.02533029572305804
R2618 263 2619 -0.025330295817311835
R2619 263 2620 -0.02533029583979945
R2620 263 2621 -0.025330295815219755
R2621 263 2622 -0.025330295829149377
R2622 263 2623 -0.025330295842514113
R2623 263 2624 -0.025330295821333903
R2624 263 2625 -0.025330295826395757
R2625 263 2626 -0.02533029583788049
R2626 263 2627 -0.025330295808295992
R2627 263 2628 -0.02533029583398764
R2628 263 2629 -0.025330295824908783
R2629 263 2630 -0.02533029582241541
R2630 263 2631 -0.025330295832432455
R2631 263 2632 -0.025330295875820294
R2632 263 2633 -0.02533029583023042
R2633 263 2634 -0.025330295874533008
R2634 263 2635 -0.02533029590127766
R2635 263 2636 -0.025330295901107677
R2636 263 2637 -0.02533029589582422
R2637 263 2638 -0.02533029580351141
R2638 263 2639 -0.025330295826992106
R2639 263 2640 -0.025330295772878108
R2640 263 2641 -0.02533029578014638
R2641 263 2642 -0.02533029585223621
R2642 263 2643 -0.025330295885861817
R2643 263 2644 -0.025330295900472716
R2644 263 2645 -0.02533029587491248
R2645 263 2646 -0.025330295896623896
R2646 263 2647 -0.025330295909339814
R2647 263 2648 -0.025330295887272633
R2648 263 2649 -0.025330295843566
R2649 263 2650 -0.025330295910565723
R2650 263 2651 -0.025330295870932065
R2651 263 2652 -0.025330295885655642
R2652 263 2653 -0.02533029588652072
R2653 263 2654 -0.025330295865032933
R2654 263 2655 -0.02533029583504187
R2655 263 2656 -0.025330295879748787
R2656 263 2657 -0.025330295822252866
R2657 263 2658 -0.025330295871208924
R2658 263 2659 -0.02533029588181138
R2659 263 2660 -0.025330295894533103
R2660 263 2661 -0.025330295827149497
R2661 263 2662 -0.02533029585093688
R2662 263 2663 -0.02533029577368823
R2663 263 2664 -0.025330295790695158
R2664 263 2665 -0.025330295857759217
R2665 263 2666 -0.025330295894260068
R2666 263 2667 -0.02533029587055918
R2667 263 2668 -0.0253302958704143
R2668 263 2669 -0.025330295882775605
R2669 263 2670 -0.025330295805225885
R2670 263 2671 -0.025330295789982683
R2671 263 2672 -0.025330295867946093
R2672 263 2673 -0.025330295887166798
R2673 263 2674 -0.025330295843195502
R2674 263 2675 -0.02533029570447162
R2675 263 2676 -0.025330295799750234
R2676 263 2677 -0.025330295847379947
R2677 263 2678 -0.025330295825288295
R2678 263 2679 -0.025330295882692477
R2679 263 2680 -0.025330295893962195
R2680 263 2681 -0.025330295897334033
R2681 263 2682 -0.02533029588034176
R2682 263 2683 -0.02533029589821975
R2683 263 2684 -0.025330295898123384
R2684 263 2685 -0.025330295805258245
R2685 263 2686 -0.02533029580721303
R2686 263 2687 -0.02533029588411473
R2687 263 2688 -0.025330295758926542
R2688 263 2689 -0.0253302958833886
R2689 263 2690 -0.025330295894433013
R2690 263 2691 -0.025330295876885723
R2691 263 2692 -0.05066059182116889
R2692 263 2693 -0.0253302958890619
R2693 263 2694 -0.025330295898511997
R2694 263 2695 -0.025330295670165492
R2695 263 2696 -0.025330295775538764
R2696 263 2697 -0.025330295736423626
R2697 263 2698 -0.025330295867498954
R2698 263 2699 -0.025330295749945633
R2699 263 2700 -0.025330295871992134
R2700 263 2701 -0.025330295832514
R2701 263 2702 -0.025330295798105786
R2702 263 2703 -0.0253302958716747
R2703 263 2704 -0.025330295771201564
R2704 263 2705 -0.025330295898170176
R2705 263 2706 -0.025330295896984423
R2706 263 2707 -0.025330295868143587
R2707 263 2708 -0.025330295870781085
R2708 263 2709 -0.02533029589751621
R2709 263 2710 -0.025330295855423433
R2710 263 2711 -0.025330295910565723
R2711 263 2712 -0.02533029589478221
R2712 263 2713 -0.02533029580376881
R2713 263 2714 -0.025330295734190274
R2714 263 2715 -0.025330295860109722
R2715 263 2716 -0.025330295826373254
R2716 263 2717 -0.025330295910565723
R2717 263 2718 -0.025330295823405905
R2718 263 2719 -0.025330295804272228
R2719 263 2720 -0.025330295857305653
R2720 263 2721 -0.025330295910565723
R2721 263 2722 -0.025330295898396554
R2722 263 2723 -0.0253302956602437
R2723 263 2724 -0.025330295670528843
R2724 263 2725 -0.02533029581781516
R2725 263 2726 -0.02533029574857204
R2726 263 2727 -0.025330295910565723
R2727 263 2728 -0.025330295910565723
R2728 263 2729 -0.02533029572726651
R2729 263 2730 -0.025330295910565723
R2730 263 2731 -0.025330295687571606
R2731 263 2732 -0.025330295872290198
R2732 263 2733 -0.025330295910565723
R2733 263 2734 -0.025330295839378583
R2734 263 2735 -0.025330295813254192
R2735 263 2736 -0.025330295894563738
R2736 263 2737 -0.025330295812337537
R2737 263 2738 -0.02533029570437544
R2738 263 2739 -0.02533029581998913
R2739 263 2740 -0.025330295850092718
R2740 263 2741 -0.025330295909853293
R2741 263 2742 -0.02533029584610772
R2742 263 2743 -0.02533029582028071
R2743 263 2744 -0.02533029588343967
R2744 263 2745 -0.025330295892528613
R2745 263 2746 -0.025330295895930676
R2746 263 2747 -0.025330295891084594
R2747 263 2748 -0.02533029589375113
R2748 263 2749 -0.0253302958987191
R2749 263 2750 -0.02533029589851919
R2750 263 2751 -0.02533029589735665
R2751 263 2752 -0.025330295899746457
R2752 263 2753 -0.025330295902129308
R2753 263 2754 -0.025330295895307185
R2754 263 2755 -0.025330295890592918
R2755 263 2756 -0.025330295899506503
R2756 263 2757 -0.025330295910565723
R2757 263 2758 -0.02533029582787272
R2758 263 2759 -0.025330295756658523
R2759 263 2760 -0.025330295837130312
R2760 263 2761 -0.025330295808580917
R2761 263 2762 -0.025330295660439633
R2762 263 2763 -0.02533029582927788
R2763 263 2764 -0.025330295829927362
R2764 263 2765 -0.025330295910565723
R2765 263 2766 -0.025330295823642587
R2766 263 2767 -0.02533029587902446
R2767 263 2768 -0.02533029588087302
R2768 263 2769 -0.025330295867608835
R2769 263 2770 -0.025330295853576774
R2770 263 2771 -0.02533029572933683
R2771 263 2772 -0.025330295643216743
R2772 263 2773 -0.025330295910565723
R2773 263 2774 -0.025330295910565723
R2774 263 2775 -0.025330295778709946
R2775 263 2776 -0.025330295826919716
R2776 263 2777 -0.025330295868692388
R2777 263 2778 -0.025330295910565723
R2778 263 2779 -0.025330295822864016
R2779 263 2780 -0.025330295824677867
R2780 263 2781 -0.0253302958403296
R2781 263 2782 -0.025330295910565723
R2782 263 2783 -0.025330295910565723
R2783 263 2784 -0.025330295910565723
R2784 263 2785 -0.0253302958607369
R2785 263 2786 -0.025330295700251443
R2786 263 2787 -0.025330295886967218
R2787 263 2788 -0.02533029585513018
R2788 263 2789 -0.025330295886512037
R2789 263 2790 -0.025330295882675966
R2790 263 2791 -0.025330295892131153
R2791 263 2792 -0.02533029585891081
R2792 263 2793 -0.025330295762358915
R2793 263 2794 -0.025330295868653388
R2794 263 2795 -0.025330295859726504
R2795 263 2796 -0.02533029583345346
R2796 263 2797 -0.025330295845192162
R2797 263 2798 -0.025330295816471157
R2798 263 2799 -0.025330295868402387
R2799 263 2800 -0.025330295840612495
R2800 263 2801 -0.02533029571526489
R2801 263 2802 -0.025330295872383387
R2802 263 2803 -0.025330295880393684
R2803 263 2804 -0.02533029578471901
R2804 263 2805 -0.025330295886403446
R2805 263 2806 -0.025330295895637973
R2806 263 2807 -0.025330295720589355
R2807 263 2808 -0.02533029585299027
R2808 263 2809 -0.025330295887449734
R2809 263 2810 -0.025330295858555337
R2810 263 2811 -0.025330295890485306
R2811 263 2812 -0.0253302958415359
R2812 263 2813 -0.02533029587267245
R2813 263 2814 -0.025330295853645598
R2814 263 2815 -0.02533029588471291
R2815 263 2816 -0.025330295884557315
R2816 263 2817 -0.025330295910565723
R2817 263 2818 -0.025330295869465246
R2818 263 2819 -0.025330295910565723
R2819 263 2820 -0.02533029579723473
R2820 263 2821 -0.025330295880403707
R2821 263 2822 -0.025330295910565723
R2822 263 2823 -0.02533029584907764
R2823 263 2824 -0.025330295867087918
R2824 263 2825 -0.025330295779975837
R2825 263 2826 -0.025330295910565723
R2826 263 2827 -0.025330295876096746
R2827 263 2828 -0.025330295723435894
R2828 263 2829 -0.025330295910565723
R2829 263 2830 -0.025330295910565723
R2830 263 2831 -0.025330295910565723
R2831 263 2832 -0.025330295910565723
R2832 263 2833 -0.025330295748511762
R2833 263 2834 -0.025330295910565723
R2834 263 2835 -0.025330295910565723
R2835 263 2836 -0.025330295910565723
R2836 263 2837 -0.025330295841396913
R2837 263 2838 -0.025330295910565723
R2838 263 2839 -0.025330295818699045
R2839 263 2840 -0.025330295834060226
R2840 263 2841 -0.025330295910565723
R2841 263 2842 -0.025330295910565723
R2842 263 2843 -0.02533029586687094
R2843 263 2844 -0.025330295910565723
R2844 263 2845 -0.025330295910565723
R2845 263 2846 -0.025330295910565723
R2846 263 2847 -0.025330295910565723
R2847 263 2848 -0.025330295910565723
R2848 263 2849 -0.025330295910565723
R2849 263 2850 -0.025330295837267886
R2850 263 2851 -0.025330295910565723
R2851 263 2852 -0.025330295910565723
R2852 263 2853 -0.02533029570568703
R2853 263 2854 -0.025330295793824485
R2854 263 2855 -0.025330295910565723
R2855 263 2856 -0.025330295910565723
R2856 263 2857 -0.05066059182116889
R2857 263 2858 -0.025330295910565723
R2858 263 2859 -0.05066059182116889
R2859 263 2860 -0.025330295910565723
R2860 263 2861 -0.025330295910565723
R2861 263 2862 -0.025330295910565723
R2862 263 2863 -0.025330295910565723
R2863 263 2864 -0.02533029579527884
R2864 263 2865 -0.025330295813305568
R2865 263 2866 -0.025330295897325262
R2866 263 2867 -0.025330295899298923
R2867 263 2868 -0.025330295881145683
R2868 263 2869 -0.025330295881182872
R2869 263 2870 -0.025330295795602142
R2870 263 2871 -0.025330295910565723
R2871 263 2872 -0.025330295786777715
R2872 263 2873 -0.025330295770728286
R2873 263 2874 -0.025330295752123835
R2874 263 2875 -0.025330295865934466
R2875 263 2876 -0.02533029587620292
R2876 263 2877 -0.025330295824216066
R2877 263 2878 -0.02533029583651063
R2878 263 2879 -0.025330295879369497
R2879 263 2880 -0.02533029589519525
R2880 263 2881 -0.02533029581021484
R2881 263 2882 -0.025330295910565723
R2882 263 2883 -0.025330295910565723
R2883 263 2884 -0.025330295910565723
R2884 263 2885 -0.025330295910565723
R2885 263 2886 -0.05066059182116889
R2886 263 2887 -0.025330295867238336
R2887 263 2888 -0.02533029590180634
R2888 263 2889 -0.025330295910565723
R2889 263 2890 -0.025330295910565723
R2890 263 2891 -0.025330295910565723
R2891 263 2892 -0.025330295910565723
R2892 263 2893 -0.025330295910565723
R2893 263 2894 -0.025330295910565723
R2894 263 2895 -0.025330295910565723
R2895 263 2896 -0.025330295910565723
R2896 263 2897 -0.025330295910565723
R2897 263 2898 -0.025330295910565723
R2898 263 2899 -0.025330295910565723
R2899 263 2900 -0.025330295910565723
R2900 263 2901 -0.025330295910565723
R2901 263 2902 -0.025330295910565723
R2902 263 2903 -0.025330295910565723
R2903 263 2904 -0.025330295910565723
R2904 263 2905 -0.025330295910565723
R2905 263 2906 -0.025330295910565723
R2906 263 2907 -0.025330295910565723
R2907 263 2908 -0.025330295910565723
R2908 263 2909 -0.025330295869029705
R2909 263 2910 -0.0253302958772142
R2910 263 2911 -0.025330295530988214
R2911 263 2912 -0.025330295910565723
R2912 263 2913 -0.0253302958939993
R2913 263 2914 -0.025330295910565723
R2914 263 2915 -0.025330295910565723
R2915 263 2916 -0.025330295880732344
R2916 263 2917 -0.025330295889635854
R2917 263 2918 -0.025330295895286254
R2918 263 2919 -0.02533029588235512
R2919 263 2920 -0.025330295880459115
R2920 263 2921 -0.025330295910565723
R2921 263 2922 -0.025330295910565723
R2922 263 2923 -0.025330295910565723
R2923 263 2924 -0.025330295910565723
R2924 263 2925 -0.025330295733428033
R2925 263 2926 -0.025330295910565723
R2926 263 2927 -0.025330295910565723
R2927 263 2928 -0.025330295910565723
R2928 263 2929 -0.025330295910565723
R2929 263 2930 -0.025330295910565723
R2930 263 2931 -0.025330295910565723
R2931 263 2932 -0.025330295910565723
R2932 263 2933 -0.025330295910565723
R2933 263 2934 -0.025330295910565723
R2934 263 2935 -0.025330295910565723
R2935 263 2936 -0.025330295910565723
R2936 263 2937 -0.025330295910565723
R2937 263 2938 -0.025330295910565723
R2938 263 2939 -0.025330295910565723
R2939 263 2940 -0.025330295910565723
R2940 263 2941 -0.025330295910565723
R2941 263 2942 -0.025330295910565723
R2942 263 2943 -0.025330295910565723
R2943 263 2944 -0.025330295910565723
R2944 263 2945 -0.025330295910565723
R2945 263 2946 -0.025330295910565723
R2946 263 2947 -0.025330295910565723
R2947 263 2948 -0.025330295910565723
R2948 263 2949 -0.025330295910565723
R2949 263 2950 -0.025330295910565723
R2950 263 2951 -0.025330295910565723
R2951 263 2952 -0.025330295910565723
R2952 263 2953 -0.025330295910565723
R2953 263 2954 -0.025330295910565723
R2954 263 2955 -0.025330295910565723
R2955 263 2956 -0.025330295910565723
R2956 263 2957 -0.025330295910565723
R2957 263 2958 -0.025330295910565723
R2958 263 2959 -0.025330295910565723
R2959 263 2960 -0.025330295910565723
R2960 263 2961 -0.025330295910565723
R2961 263 2962 -0.025330295910565723
R2962 263 2963 -0.025330295910565723
R2963 263 2964 -0.025330295910565723
R2964 263 2965 -0.025330295910565723
R2965 263 2966 -0.025330295910565723
R2966 263 2967 -0.025330295910565723
R2967 263 2968 -0.025330295910565723
R2968 263 2969 -0.025330295910565723
R2969 263 2970 -0.025330295872721
R2970 263 2971 -0.025330295910565723
R2971 263 2972 -0.025330295891434058
R2972 263 2973 -0.02533029582124145
R2973 263 2974 -0.025330295891271587
R2974 263 2975 -0.025330295910565723
R2975 263 2976 -0.02533029589025623
