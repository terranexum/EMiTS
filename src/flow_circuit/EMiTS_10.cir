.title EMiTS_10
L1 7 8 -0.006332517585423507
L2 7 9 -0.006332517585423507
L3 2 7 -0.008443393948209536
L4 6 7 -0.008443393948209536
L5 7 10 -0.006332517585423507
L6 3 7 -0.037900185592025445
L7 5 7 -0.03545114991187057
L8 1 7 -0.012665097828624138
L9 4 7 -0.020255830324559382
